options:
  parameters:
    author: arosh
    generate_options: qt_gui
    id: attempt_4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\arosh\OneDrive\Desktop\GNU receive.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\arosh\OneDrive\Desktop\GNU transmit.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '252'
    type: byte
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: qpsk
    npwr: '0'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'False'
  states: {state: disabled}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """Example ACK generator"""
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="ACK Generator",
                  in_sig=[],
                  out_sig=[]
              )
              # Define message port for PDU output
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              # msg is a PDU received from upstream
              # You can check packet integrity here
              if self.check_crc(msg):
                  # Construct ACK PDU
                  ack = pmt.cons(pmt.make_dict(), pmt.init_u8vector(3, bytearray(b"ACK")))
                  self.message_port_pub(pmt.intern("out"), ack)

          def check_crc(self, msg):
              # Add your CRC check logic
              return True
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          Writes Tagged Stream (converted to PDU) into a file, 
          including metadata (tags).
          """

          def __init__(self, filename="C:/Users/arosh/OneDrive/Desktop/output.txt"):
              gr.basic_block.__init__(
                  self,
                  name="TaggedStreamToFile",
                  in_sig=[],
                  out_sig=[]
              )
              self.filename = filename

              # Register message input port
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              # msg is a PDU = (metadata dict, data vector)
              meta = pmt.car(msg)        # metadata dictionary
              data = pmt.cdr(msg)        # u8vector payload

              # Convert data to Python bytes
              data_bytes = bytes(pmt.u8vector_elements(data))

              # Convert metadata to string
              meta_str = pmt.write_string(meta)

              # Write both to file
              with open(self.filename, "ab") as f:
                  f.write(b"==== NEW PACKET ====\n")
                  f.write(f"Metadata: {meta_str}\n".encode())
                  f.write(b"Payload: " + data_bytes + b"\n\n")
    filename: '"C:/Users/arosh/OneDrive/Desktop/output.txt"'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class ack_block(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="AckBlock",
                  in_sig=[],
                  out_sig=[])

              # Input: received PDUs
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              # Output: ACK/NACK PDUs
              self.message_port_register_out(pmt.intern("out"))

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              data = pmt.cdr(msg)
              payload = bytes(pmt.u8vector_elements(data))

              # Check CRC flag in metadata
              if pmt.dict_has_key(meta, pmt.intern("crc_ok")):
                  crc_ok = pmt.to_bool(pmt.dict_ref(meta, pmt.intern("crc_ok"), pmt.PMT_F))
              else:
                  crc_ok = True  # assume good if no CRC info

              seq = pmt.dict_ref(meta, pmt.intern("seq"), pmt.from_long(-1))

              if crc_ok:
                  ack_meta = pmt.make_dict()
                  ack_meta = pmt.dict_add(ack_meta, pmt.intern("ack"), pmt.from_long(pmt.to_long(seq)))
                  ack_pdu = pmt.cons(ack_meta, pmt.make_u8vector(0, 0))
                  print(">>> ACK sent for packet", pmt.to_long(seq))
              else:
                  nack_meta = pmt.make_dict()
                  nack_meta = pmt.dict_add(nack_meta, pmt.intern("nack"), pmt.from_long(pmt.to_long(seq)))
                  nack_pdu = pmt.cons(nack_meta, pmt.make_u8vector(0, 0))
                  print(">>> NACK sent for packet", pmt.to_long(seq))
                  self.message_port_pub(pmt.intern("out"), nack_pdu)
                  return

              self.message_port_pub(pmt.intern("out"), ack_pdu)
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import time
      from gnuradio import gr

      class stop_and_wait_tx(gr.basic_block):
          def __init__(self, timeout=0.5):
              gr.basic_block.__init__(self,
                  name="Stop-and-Wait TX",
                  in_sig=[],
                  out_sig=[]
              )
              # Message ports
              self.message_port_register_in(pmt.intern("in"))    # Data to send
              self.message_port_register_in(pmt.intern("ack"))   # ACK/NACK input
              self.message_port_register_out(pmt.intern("out"))  # Transmit PDU

              self.set_msg_handler(pmt.intern("in"), self.handle_new_packet)
              self.set_msg_handler(pmt.intern("ack"), self.handle_ack)

              self.last_packet = None
              self.waiting_ack = False
              self.timeout = timeout
              self.last_send_time = 0

          def handle_new_packet(self, msg):
              if not self.waiting_ack:
                  self.last_packet = msg
                  self.send_packet(msg)

          def handle_ack(self, msg):
              # Check if msg is ACK or NACK
              meta = pmt.car(msg)
              if pmt.dict_has_key(meta, pmt.intern("ack")):
                  seq = pmt.to_long(pmt.dict_ref(meta, pmt.intern("ack"), pmt.PMT_NIL))
                  print("ACK received for seq:", seq)
                  self.waiting_ack = False
              elif pmt.dict_has_key(meta, pmt.intern("nack")):
                  seq = pmt.to_long(pmt.dict_ref(meta, pmt.intern("nack"), pmt.PMT_NIL))
                  print("NACK received for seq:", seq)
                  # Retransmit immediately
                  self.send_packet(self.last_packet)

          def send_packet(self, msg):
              self.message_port_pub(pmt.intern("out"), msg)
              self.waiting_ack = True
              self.last_send_time = time.time()

          def work(self, input_items, output_items):
              # Check timeout
              if self.waiting_ack and time.time() - self.last_send_time > self.timeout:
                  print("Timeout! Retransmitting...")
                  self.send_packet(self.last_packet)
              return 0
    timeout: '0.5'
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pack_k_bits_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_throttle2_0_1, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_1, '0', channels_channel_model_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_1, '0', digital_symbol_sync_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', qtgui_time_sink_x_0_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_crc32_bb_0, '0', digital_constellation_modulator_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_crc_append_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_crc_check_0, fail, epy_block_0, in]
- [digital_crc_check_0, fail, epy_block_1, in]
- [digital_crc_check_0, fail, epy_block_2, in]
- [digital_crc_check_0, ok, pdu_pdu_to_stream_x_0, pdus]
- [digital_crc_check_0, ok, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_2, out, epy_block_3, ack]
- [epy_block_3, out, digital_crc_append_0, in]
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc32_bb_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_check_0, in]
- [pdu_tagged_stream_to_pdu_1, pdus, epy_block_3, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
