options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_8
    output_language: python
    title: pkt_8
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '42'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: extra_bytes
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 100e3
    stop: 6e9
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '00'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.2'
  states: {state: disabled}
- name: num_duplicates
  id: variable
  parameters:
    value: '8'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.05'
  states: {state: disabled}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {state: disabled}
- name: phase_bw
  id: variable
  parameters:
    value: 6.28/100.0
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: sample_rate_blade
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: tuning_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Tuning
    start: '-70e3'
    step: '50'
    stop: 70e3
    value: '-21e3'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_2
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: channels_channel_model_0_1
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_1
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Repeater (Aggressive Flush)
      Function: 
      1. Repeats ACKs 'N' times (Burst).
      2. AGGRESSIVE FLUSH: If a new MsgID or newer RN comes, 
         it DELETES the entire old queue immediately to prioritize the latest status.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class ack_repeater(gr.basic_block):
          def __init__(self, num_repeats=5, delay=0.05):
              """
              num_repeats: How many times to burst the ACK.
              delay: Time between burst packets.
              """
              gr.basic_block.__init__(self,
                  name="ACK Repeater",
                  in_sig=None,
                  out_sig=None)

              self.num_repeats = num_repeats
              self.delay = delay
              
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              
              # State
              self.queue = []
              self.current_task = None
              self.preempt_flag = False 
              
              self.lock = threading.Lock()
              self.running = True
              self.worker = threading.Thread(target=self.process_loop, daemon=True)
              self.worker.start()

          def get_header_info(self, u8_list):
              try:
                  # Header: [Dst(4)|Src(4)|Type(1)|MsgID(1)|RN(1)|Prio(1)]
                  # MsgID is at index 9, RN at index 10
                  msg_id = u8_list[9]
                  rn_num = u8_list[10]
                  return msg_id, rn_num
              except:
                  return 0, 0

          def handle_msg(self, msg):
              """
              Receives new ACK. 
              If it's newer than what we are sending, FLUSH everything and start this one.
              """
              with self.lock:
                  payload = pmt.cdr(msg)
                  if not pmt.is_u8vector(payload): return
                  u8_list = list(pmt.u8vector_elements(payload))
                  if len(u8_list) < 12: return

                  new_msg_id, new_rn = self.get_header_info(u8_list)
                  
                  new_task = {
                      'pdu': msg,
                      'msg_id': new_msg_id,
                      'rn': new_rn
                  }

                  # --- AGGRESSIVE LOGIC ---
                  # Do we have a current task?
                  if self.current_task:
                      curr_id = self.current_task['msg_id']
                      curr_rn = self.current_task['rn']
                      
                      # Condition 1: Is this a completely NEW Message ID?
                      is_new_msg = (new_msg_id != curr_id)
                      
                      # Condition 2: Is this the SAME Message but a NEWER Request Number?
                      is_newer_rn = (new_msg_id == curr_id and new_rn > curr_rn)
                      
                      if is_new_msg or is_newer_rn:
                          # 1. Clear the waiting queue completely (Delete old ACKs)
                          self.queue.clear()
                          
                          # 2. Trigger interrupt for the worker thread
                          self.preempt_flag = True
                          
                          # 3. Queue this new task as the priority
                          self.queue.append(new_task)
                          # Optional Debug:
                          # print(f"[ACK Rpt] FLUSHING! Stopped {curr_id}:{curr_rn} -> Starting {new_msg_id}:{new_rn}")
                      else:
                          # It's an old or duplicate ACK. Ignore it to save bandwidth.
                          pass
                  else:
                      # We are idle. Just add it to the queue.
                      # If queue has items, check if this one is newer than the last one in queue
                      if len(self.queue) > 0:
                          last_task = self.queue[-1]
                          last_id = last_task['msg_id']
                          last_rn = last_task['rn']
                          
                          if (new_msg_id != last_id) or (new_msg_id == last_id and new_rn > last_rn):
                              self.queue.clear()
                              self.queue.append(new_task)
                      else:
                          self.queue.append(new_task)

          def process_loop(self):
              while self.running:
                  task = None
                  
                  # Get next task
                  with self.lock:
                      if len(self.queue) > 0:
                          task = self.queue.pop(0)
                          self.current_task = task
                          self.preempt_flag = False # Reset flag for new task
                      else:
                          self.current_task = None

                  # If nothing to do, sleep
                  if task is None:
                      time.sleep(0.01)
                      continue

                  # --- BURST LOOP ---
                  for i in range(self.num_repeats):
                      # Check for interrupt signal from handle_msg
                      if self.preempt_flag:
                          break 
                      
                      # Send
                      self.message_port_pub(pmt.intern("out"), task['pdu'])
                      time.sleep(self.delay)
    delay: '1'
    num_repeats: '20'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Repeater (Aggressive Flush)
      Function: 
      1. Repeats ACKs 'N' times (Burst).
      2. AGGRESSIVE FLUSH: If a new MsgID or newer RN comes, 
         it DELETES the entire old queue immediately to prioritize the latest status.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class ack_repeater(gr.basic_block):
          def __init__(self, num_repeats=5, delay=0.05):
              """
              num_repeats: How many times to burst the ACK.
              delay: Time between burst packets.
              """
              gr.basic_block.__init__(self,
                  name="ACK Repeater",
                  in_sig=None,
                  out_sig=None)

              self.num_repeats = num_repeats
              self.delay = delay
              
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              
              # State
              self.queue = []
              self.current_task = None
              self.preempt_flag = False 
              
              self.lock = threading.Lock()
              self.running = True
              self.worker = threading.Thread(target=self.process_loop, daemon=True)
              self.worker.start()

          def get_header_info(self, u8_list):
              try:
                  # Header: [Dst(4)|Src(4)|Type(1)|MsgID(1)|RN(1)|Prio(1)]
                  # MsgID is at index 9, RN at index 10
                  msg_id = u8_list[9]
                  rn_num = u8_list[10]
                  return msg_id, rn_num
              except:
                  return 0, 0

          def handle_msg(self, msg):
              """
              Receives new ACK. 
              If it's newer than what we are sending, FLUSH everything and start this one.
              """
              with self.lock:
                  payload = pmt.cdr(msg)
                  if not pmt.is_u8vector(payload): return
                  u8_list = list(pmt.u8vector_elements(payload))
                  if len(u8_list) < 12: return

                  new_msg_id, new_rn = self.get_header_info(u8_list)
                  
                  new_task = {
                      'pdu': msg,
                      'msg_id': new_msg_id,
                      'rn': new_rn
                  }

                  # --- AGGRESSIVE LOGIC ---
                  # Do we have a current task?
                  if self.current_task:
                      curr_id = self.current_task['msg_id']
                      curr_rn = self.current_task['rn']
                      
                      # Condition 1: Is this a completely NEW Message ID?
                      is_new_msg = (new_msg_id != curr_id)
                      
                      # Condition 2: Is this the SAME Message but a NEWER Request Number?
                      is_newer_rn = (new_msg_id == curr_id and new_rn > curr_rn)
                      
                      if is_new_msg or is_newer_rn:
                          # 1. Clear the waiting queue completely (Delete old ACKs)
                          self.queue.clear()
                          
                          # 2. Trigger interrupt for the worker thread
                          self.preempt_flag = True
                          
                          # 3. Queue this new task as the priority
                          self.queue.append(new_task)
                          # Optional Debug:
                          # print(f"[ACK Rpt] FLUSHING! Stopped {curr_id}:{curr_rn} -> Starting {new_msg_id}:{new_rn}")
                      else:
                          # It's an old or duplicate ACK. Ignore it to save bandwidth.
                          pass
                  else:
                      # We are idle. Just add it to the queue.
                      # If queue has items, check if this one is newer than the last one in queue
                      if len(self.queue) > 0:
                          last_task = self.queue[-1]
                          last_id = last_task['msg_id']
                          last_rn = last_task['rn']
                          
                          if (new_msg_id != last_id) or (new_msg_id == last_id and new_rn > last_rn):
                              self.queue.clear()
                              self.queue.append(new_task)
                      else:
                          self.queue.append(new_task)

          def process_loop(self):
              while self.running:
                  task = None
                  
                  # Get next task
                  with self.lock:
                      if len(self.queue) > 0:
                          task = self.queue.pop(0)
                          self.current_task = task
                          self.preempt_flag = False # Reset flag for new task
                      else:
                          self.current_task = None

                  # If nothing to do, sleep
                  if task is None:
                      time.sleep(0.01)
                      continue

                  # --- BURST LOOP ---
                  for i in range(self.num_repeats):
                      # Check for interrupt signal from handle_msg
                      if self.preempt_flag:
                          break 
                      
                      # Send
                      self.message_port_pub(pmt.intern("out"), task['pdu'])
                      time.sleep(self.delay)
    delay: '1'
    num_repeats: '20'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: CRC Fail Logger (With Counter)
      Function: 
      1. Counts total CRC failures.
      2. Prints warning + count + packet length to console.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime

      class crc_fail_logger(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="CRC Fail Logger",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              
              # Initialize Counter
              self.fail_count = 0

          def get_timestamp(self):
              return datetime.datetime.now().strftime("%H:%M:%S")

          def handle_msg(self, msg):
              try:
                  # Increment Counter
                  self.fail_count += 1
                  timestamp = self.get_timestamp()
                  
                  # Check length to distinguish noise from partial packets
                  payload = pmt.cdr(msg)
                  length_str = "?"
                  if pmt.is_u8vector(payload):
                      length = len(pmt.u8vector_elements(payload))
                      length_str = str(length)

                  # Print Detailed Log
                  print(f"[{timestamp}] [CRC FAIL] Corrupted packet received (Length: {length_str} bytes). Discarding. #{self.fail_count}")
                      
              except Exception as e:
                  print(f"[CRC Logger] Error: {e}")
  states: {}
- name: epy_block_10
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Splitter
      Function: Splits a large PDU into N smaller PDUs and sends them sequentially.
      """
      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_splitter(gr.basic_block):
          def __init__(self, num_duplicates=3):
              # NOTE: Make sure this matches your Transmitter's num_duplicates!
              gr.basic_block.__init__(self,
                  name="PDU Splitter",
                  in_sig=None,
                  out_sig=None)
              
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  if pmt.is_pdu(msg):
                      meta = pmt.car(msg)
                      vector_data = pmt.cdr(msg)
                      
                      # Get Data
                      data = list(pmt.u8vector_elements(vector_data))
                      total_len = len(data)
                      
                      # --- VALIDATION ---
                      # The total length must be exactly divisible by N.
                      # If not, the packet header length tag was likely corrupted by noise.
                      if total_len == 0:
                          return
                      
                      if total_len % self.n != 0:
                          # print(f"[Splitter] Dropping malformed packet. Length {total_len} not divisible by {self.n}")
                          return

                      # Calculate single packet size
                      chunk_len = total_len // self.n
                      
                      # --- SPLIT & SEND LOOP ---
                      for i in range(self.n):
                          start = i * chunk_len
                          end = start + chunk_len
                          
                          # Slice the data
                          sub_packet = data[start:end]
                          
                          # Create PDU
                          out_vector = pmt.init_u8vector(len(sub_packet), sub_packet)
                          out_msg = pmt.cons(meta, out_vector)
                          
                          # Publish
                          self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                          
              except Exception as e:
                  print(f"[Splitter] Error: {e}")
    num_duplicates: num_duplicates
  states: {}
- name: epy_block_10_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Prepend Dummy
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_prepend_dummy(gr.basic_block):
          def __init__(self, dummy_bytes=20):
              """
              Args:
                  dummy_bytes: Number of '0x55' bytes to add to the front.
              """
              gr.basic_block.__init__(self,
                  name="PDU Prepend Dummy",
                  in_sig=None,
                  out_sig=None)

              self.d_len = dummy_bytes

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              original_data = list(pmt.u8vector_elements(data_pdu))
              
              # 3. Create Dummy Data
              # We use 0x55 (Binary: 01010101) because it creates excellent 
              # bit transitions for synchronization.
              dummy_pattern = [0x55] * self.d_len
              
              # 4. Prepend (Dummy + Original)
              new_data = dummy_pattern + original_data
              
              # 5. Pack and Publish
              out_vector = pmt.init_u8vector(len(new_data), new_data)
              out_msg = pmt.cons(meta, out_vector)
              
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    dummy_bytes: extra_bytes
  states: {state: disabled}
- name: epy_block_11
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Selective AES Decryptor
      Function:
      1. Reads 12-Byte Cleartext Header.
      2. Decrypts the Payload (Bytes 12+) using AES-128 ECB.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES

      class selective_aes_decrypt(gr.basic_block):
          def __init__(self, key_str="1234567890123456"):
              gr.basic_block.__init__(self,
                  name="Selective AES Decryptor",
                  in_sig=None,
                  out_sig=None)

              self.key = key_str.encode('utf-8')[:16]
              while len(self.key) < 16:
                  self.key += b'\0'

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  data = list(pmt.u8vector_elements(payload_pmt))
                  
                  # Header is 12 bytes
                  if len(data) < 12:
                      return

                  # 1. Split Header and Encrypted Payload
                  header = data[0:12]
                  encrypted_payload = data[12:]
                  
                  # 2. Decrypt
                  if len(encrypted_payload) > 0 and len(encrypted_payload) % 16 == 0:
                      try:
                          cipher = AES.new(self.key, AES.MODE_ECB)
                          decrypted_bytes = cipher.decrypt(bytes(encrypted_payload))
                          
                          # 3. Recombine
                          final_packet = header + list(decrypted_bytes)
                          
                          # 4. Output
                          out_pdu = pmt.init_u8vector(len(final_packet), final_packet)
                          out_msg = pmt.cons(pmt.PMT_NIL, out_pdu)
                          self.message_port_pub(pmt.intern("out"), out_msg)
                          
                      except ValueError:
                          print("[AES Decrypt] Decryption Failed (Key mismatch or corrupt data)")
                  else:
                      # If payload is empty or not aligned, pass it through (might be header only)
                      # or drop it. Here we pass it safe.
                      self.message_port_pub(pmt.intern("out"), msg)

              except Exception as e:
                  print(f"[AES Decrypt] Error: {e}")
    key_str: '"1234567890123456"'
  states: {}
- name: epy_block_11_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Head Stripper
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_head_stripper(gr.basic_block):
          def __init__(self, strip_bytes=20):
              """
              Args:
                  strip_bytes: Number of bytes to remove from the beginning of the packet.
              """
              gr.basic_block.__init__(self,
                  name="PDU Head Stripper",
                  in_sig=None,
                  out_sig=None)

              self.n_strip = strip_bytes

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = pmt.u8vector_elements(data_pdu)
              
              # 3. Safety Check
              # If packet is smaller than what we want to strip, drop it.
              if len(data_bytes) <= self.n_strip:
                  return

              # 4. Strip the Head
              # We take everything starting from index 'n_strip' to the end
              clean_data = data_bytes[self.n_strip:]
              
              # 5. Pack and Publish
              out_vector = pmt.init_u8vector(len(clean_data), clean_data)
              out_msg = pmt.cons(meta, out_vector)
              
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    strip_bytes: '3200'
  states: {state: disabled}
- name: epy_block_11_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Selective AES Decryptor
      Function:
      1. Reads 12-Byte Cleartext Header.
      2. Decrypts the Payload (Bytes 12+) using AES-128 ECB.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES

      class selective_aes_decrypt(gr.basic_block):
          def __init__(self, key_str="1234567890123456"):
              gr.basic_block.__init__(self,
                  name="Selective AES Decryptor",
                  in_sig=None,
                  out_sig=None)

              self.key = key_str.encode('utf-8')[:16]
              while len(self.key) < 16:
                  self.key += b'\0'

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  data = list(pmt.u8vector_elements(payload_pmt))
                  
                  # Header is 12 bytes
                  if len(data) < 12:
                      return

                  # 1. Split Header and Encrypted Payload
                  header = data[0:12]
                  encrypted_payload = data[12:]
                  
                  # 2. Decrypt
                  if len(encrypted_payload) > 0 and len(encrypted_payload) % 16 == 0:
                      try:
                          cipher = AES.new(self.key, AES.MODE_ECB)
                          decrypted_bytes = cipher.decrypt(bytes(encrypted_payload))
                          
                          # 3. Recombine
                          final_packet = header + list(decrypted_bytes)
                          
                          # 4. Output
                          out_pdu = pmt.init_u8vector(len(final_packet), final_packet)
                          out_msg = pmt.cons(pmt.PMT_NIL, out_pdu)
                          self.message_port_pub(pmt.intern("out"), out_msg)
                          
                      except ValueError:
                          print("[AES Decrypt] Decryption Failed (Key mismatch or corrupt data)")
                  else:
                      # If payload is empty or not aligned, pass it through (might be header only)
                      # or drop it. Here we pass it safe.
                      self.message_port_pub(pmt.intern("out"), msg)

              except Exception as e:
                  print(f"[AES Decrypt] Error: {e}")
    key_str: '"1234567890123456"'
  states: {}
- name: epy_block_12
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Priority PDU Mux (Strict Scheduler)
      Function: Buffers and releases packets based on strict 4-level priority.
      1. Emergency ACKs
      2. Emergency Messages
      3. Normal ACKs
      4. Normal Messages
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class priority_mux(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Priority PDU Mux",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Inputs
              self.message_port_register_in(pmt.intern("data_in")) # From Storage
              self.message_port_register_in(pmt.intern("ack_in"))  # From ACK Gen
              
              # 2. Register Output
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 3. Bind Handlers
              self.set_msg_handler(pmt.intern("data_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("ack_in"), self.handle_pdu) # Use same handler for logic
              
              # 4. Internal Queues (Strict Priority)
              self.q1_ack_high = [] # Ack E
              self.q2_msg_high = [] # Msg E
              self.q3_ack_low  = [] # Ack N
              self.q4_msg_low  = [] # Msg N

              self.running = True
              self.lock = threading.Lock()

              # 5. Start Scheduler Thread
              self.worker = threading.Thread(target=self.process_loop, daemon=True)
              self.worker.start()

          def get_header_info(self, u8_list):
              """
              Reads Header:
              Byte 8  = Type ('M' or 'A')
              Byte 11 = Priority ('E' or 'N')
              """
              try:
                  pkt_type = u8_list[8]
                  prio_byte = u8_list[11]
                  return pkt_type, prio_byte
              except IndexError:
                  # Malformed packet, default to Normal Msg to flush it out
                  return ord('M'), ord('N')

          def handle_pdu(self, msg):
              """
              Buffering Handler.
              Instead of sending immediately, we inspect and queue it.
              """
              with self.lock:
                  payload = pmt.cdr(msg)
                  
                  # Convert to list to read bytes
                  if pmt.is_u8vector(payload):
                      u8_list = list(pmt.u8vector_elements(payload))
                  else:
                      return # Ignore invalid data

                  pkt_type, prio_byte = self.get_header_info(u8_list)
                  
                  # --- SORTING LOGIC ---
                  
                  # 1. Emergency ACKs (Type=A, Prio=E)
                  if pkt_type == ord('A') and prio_byte == ord('E'):
                      self.q1_ack_high.append(u8_list)
                      
                  # 2. Emergency Msgs (Type=M, Prio=E)
                  elif pkt_type == ord('M') and prio_byte == ord('E'):
                      self.q2_msg_high.append(u8_list)
                      
                  # 3. Normal ACKs (Type=A, Prio!=E)
                  elif pkt_type == ord('A'):
                      self.q3_ack_low.append(u8_list)
                      
                  # 4. Normal Msgs (Type=M, Prio!=E)
                  else:
                      self.q4_msg_low.append(u8_list)

          def process_loop(self):
              """
              Active Scheduler Thread.
              Checks queues in strict 1 -> 4 order.
              """
              while self.running:
                  packet_to_send = None
                  
                  with self.lock:
                      # Strict Priority Check
                      if len(self.q1_ack_high) > 0:
                          packet_to_send = self.q1_ack_high.pop(0)
                          # Optional: print("[Mux] Sending Priority 1: Emergency ACK")
                          
                      elif len(self.q2_msg_high) > 0:
                          packet_to_send = self.q2_msg_high.pop(0)
                          # Optional: print("[Mux] Sending Priority 2: Emergency Msg")
                          
                      elif len(self.q3_ack_low) > 0:
                          packet_to_send = self.q3_ack_low.pop(0)
                          # Optional: print("[Mux] Sending Priority 3: Normal ACK")
                          
                      elif len(self.q4_msg_low) > 0:
                          packet_to_send = self.q4_msg_low.pop(0)
                          # Optional: print("[Mux] Sending Priority 4: Normal Msg")

                  if packet_to_send:
                      # Construct PMT and Send
                      out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet_to_send), packet_to_send))
                      self.message_port_pub(pmt.intern("pdu_out"), out_pmt)
                      
                      # Small delay to prevent bus saturation
                      time.sleep(0.001) 
                  else:
                      # Idle sleep to save CPU
                      time.sleep(0.01)
  states: {}
- name: epy_block_12_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Priority PDU Mux (Strict Scheduler)
      Function: Buffers and releases packets based on strict 4-level priority.
      1. Emergency ACKs
      2. Emergency Messages
      3. Normal ACKs
      4. Normal Messages
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class priority_mux(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Priority PDU Mux",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Inputs
              self.message_port_register_in(pmt.intern("data_in")) # From Storage
              self.message_port_register_in(pmt.intern("ack_in"))  # From ACK Gen
              
              # 2. Register Output
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 3. Bind Handlers
              self.set_msg_handler(pmt.intern("data_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("ack_in"), self.handle_pdu) # Use same handler for logic
              
              # 4. Internal Queues (Strict Priority)
              self.q1_ack_high = [] # Ack E
              self.q2_msg_high = [] # Msg E
              self.q3_ack_low  = [] # Ack N
              self.q4_msg_low  = [] # Msg N

              self.running = True
              self.lock = threading.Lock()

              # 5. Start Scheduler Thread
              self.worker = threading.Thread(target=self.process_loop, daemon=True)
              self.worker.start()

          def get_header_info(self, u8_list):
              """
              Reads Header:
              Byte 8  = Type ('M' or 'A')
              Byte 11 = Priority ('E' or 'N')
              """
              try:
                  pkt_type = u8_list[8]
                  prio_byte = u8_list[11]
                  return pkt_type, prio_byte
              except IndexError:
                  # Malformed packet, default to Normal Msg to flush it out
                  return ord('M'), ord('N')

          def handle_pdu(self, msg):
              """
              Buffering Handler.
              Instead of sending immediately, we inspect and queue it.
              """
              with self.lock:
                  payload = pmt.cdr(msg)
                  
                  # Convert to list to read bytes
                  if pmt.is_u8vector(payload):
                      u8_list = list(pmt.u8vector_elements(payload))
                  else:
                      return # Ignore invalid data

                  pkt_type, prio_byte = self.get_header_info(u8_list)
                  
                  # --- SORTING LOGIC ---
                  
                  # 1. Emergency ACKs (Type=A, Prio=E)
                  if pkt_type == ord('A') and prio_byte == ord('E'):
                      self.q1_ack_high.append(u8_list)
                      
                  # 2. Emergency Msgs (Type=M, Prio=E)
                  elif pkt_type == ord('M') and prio_byte == ord('E'):
                      self.q2_msg_high.append(u8_list)
                      
                  # 3. Normal ACKs (Type=A, Prio!=E)
                  elif pkt_type == ord('A'):
                      self.q3_ack_low.append(u8_list)
                      
                  # 4. Normal Msgs (Type=M, Prio!=E)
                  else:
                      self.q4_msg_low.append(u8_list)

          def process_loop(self):
              """
              Active Scheduler Thread.
              Checks queues in strict 1 -> 4 order.
              """
              while self.running:
                  packet_to_send = None
                  
                  with self.lock:
                      # Strict Priority Check
                      if len(self.q1_ack_high) > 0:
                          packet_to_send = self.q1_ack_high.pop(0)
                          # Optional: print("[Mux] Sending Priority 1: Emergency ACK")
                          
                      elif len(self.q2_msg_high) > 0:
                          packet_to_send = self.q2_msg_high.pop(0)
                          # Optional: print("[Mux] Sending Priority 2: Emergency Msg")
                          
                      elif len(self.q3_ack_low) > 0:
                          packet_to_send = self.q3_ack_low.pop(0)
                          # Optional: print("[Mux] Sending Priority 3: Normal ACK")
                          
                      elif len(self.q4_msg_low) > 0:
                          packet_to_send = self.q4_msg_low.pop(0)
                          # Optional: print("[Mux] Sending Priority 4: Normal Msg")

                  if packet_to_send:
                      # Construct PMT and Send
                      out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet_to_send), packet_to_send))
                      self.message_port_pub(pmt.intern("pdu_out"), out_pmt)
                      
                      # Small delay to prevent bus saturation
                      time.sleep(0.001) 
                  else:
                      # Idle sleep to save CPU
                      time.sleep(0.01)
  states: {}
- name: epy_block_13
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Decrypted MSG Logger
      Function: Prints details + PLAINTEXT content of every incoming packet.
      Input: Expects Decrypted PDU (Header + Cleartext Payload).
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime

      class msg_logger(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Decrypted MSG Logger",
                  in_sig=None,
                  out_sig=None)

              # Register Input Port
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def get_timestamp(self):
              return datetime.datetime.now().strftime("%H:%M:%S")

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  
                  if pmt.is_u8vector(payload):
                      data = list(pmt.u8vector_elements(payload))
                      
                      # Header Safety Check (Min 12 bytes)
                      if len(data) >= 12:
                          # --- 1. Parse Header ---
                          src_ip = ".".join(map(str, data[4:8]))
                          msg_id = data[9]
                          seq_num = data[10]
                          prio_byte = data[11]
                          prio_char = chr(prio_byte) if prio_byte in [ord('E'), ord('N')] else '?'
                          
                          # --- 2. Parse Payload (Text) ---
                          # Since this is AFTER decryption, bytes 12+ are the message text.
                          raw_text_bytes = data[12:]
                          
                          # Filter out padding (0x00) and non-printable chars
                          clean_text = "".join([chr(b) for b in raw_text_bytes if 32 <= b <= 126])
                          
                          timestamp = self.get_timestamp()
                          
                          # --- 3. Print Log ---
                          print(f"[{timestamp}] [DECRYPTED] From {src_ip} | Seq: {seq_num} | Content: '{clean_text}'")
                      else:
                          print(f"[MSG Logger] Warning: Short packet received ({len(data)} bytes)")
                  
              except Exception as e:
                  print(f"[MSG Logger] Error: {e}")
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: CRC Fail Logger (With Counter)
      Function: 
      1. Counts total CRC failures.
      2. Prints warning + count + packet length to console.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime

      class crc_fail_logger(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="CRC Fail Logger",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              
              # Initialize Counter
              self.fail_count = 0

          def get_timestamp(self):
              return datetime.datetime.now().strftime("%H:%M:%S")

          def handle_msg(self, msg):
              try:
                  # Increment Counter
                  self.fail_count += 1
                  timestamp = self.get_timestamp()
                  
                  # Check length to distinguish noise from partial packets
                  payload = pmt.cdr(msg)
                  length_str = "?"
                  if pmt.is_u8vector(payload):
                      length = len(pmt.u8vector_elements(payload))
                      length_str = str(length)

                  # Print Detailed Log
                  print(f"[{timestamp}] [CRC FAIL] Corrupted packet received (Length: {length_str} bytes). Discarding. #{self.fail_count}")
                      
              except Exception as e:
                  print(f"[CRC Logger] Error: {e}")
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Duplicator
      Function: Repeats the input PDU payload N times.
      """
      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_duplicator(gr.basic_block):
          def __init__(self, num_duplicates=3):
              gr.basic_block.__init__(self,
                  name="PDU Duplicator",
                  in_sig=None,
                  out_sig=None)
              
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  # 1. Check valid PDU
                  if pmt.is_pdu(msg):
                      meta = pmt.car(msg)
                      vector_data = pmt.cdr(msg)
                      
                      # 2. Get bytes (Payload + CRC)
                      input_bytes = list(pmt.u8vector_elements(vector_data))
                      
                      # 3. Duplicate N times
                      # Example: [A, B] * 3 -> [A, B, A, B, A, B]
                      new_bytes = input_bytes * self.n
                      
                      # 4. Create new PMT
                      out_vector = pmt.init_u8vector(len(new_bytes), new_bytes)
                      out_msg = pmt.cons(meta, out_vector)
                      
                      # 5. Send
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
              except Exception as e:
                  print(f"[Duplicator] Error: {e}")
    num_duplicates: num_duplicates
  states: {}
- name: epy_block_2_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Duplicator
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_duplicator(gr.basic_block):
          def __init__(self, num_duplicates=3):
              # Default value ensures GRC doesn't throw an error
              gr.basic_block.__init__(self,
                  name="PDU Duplicator",
                  in_sig=None,
                  out_sig=None)
              
              # Save parameter
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Check if the message is a valid PDU
              if pmt.is_pdu(msg):
                  # Extract metadata and data vector
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # 2. Convert PMT vector to a standard Python list of bytes
                  # The input 'vector_data' already contains [Payload + CRC]
                  input_bytes = pmt.u8vector_elements(vector_data)
                  
                  # 3. Duplicate the list N times
                  # In Python, [1, 2] * 3 becomes [1, 2, 1, 2, 1, 2]
                  new_bytes = list(input_bytes) * self.n
                  
                  # 4. Create a new PMT u8vector from the long list
                  out_vector = pmt.init_u8vector(len(new_bytes), new_bytes)
                  
                  # 5. Create the new PDU (preserving original metadata)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # 6. Publish
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: num_duplicates
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Debug Logger
      Function: Prints received ACK details to the console.
      Input: Expects PDU with payload [MsgID, RN] from Address Filter (ack_out).
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime

      class ack_logger(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="ACK Debug Logger",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def get_timestamp(self):
              return datetime.datetime.now().strftime("%H:%M:%S")

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  
                  # The 'ack_out' port from Address Filter sends a PDU of 2 bytes: [MsgID, RN]
                  if pmt.is_u8vector(payload):
                      data = list(pmt.u8vector_elements(payload))
                      
                      if len(data) >= 2:
                          msg_id = data[0]
                          rn_num = data[1]
                          timestamp = self.get_timestamp()
                          
                          print(f"[{timestamp}] [ACK RECV] Received ACK for MsgID: {msg_id}, Requesting Next Seq: {rn_num}")
                      else:
                          print(f"[ACK Logger] Warning: Received short ACK payload (<2 bytes)")
                  
              except Exception as e:
                  print(f"[ACK Logger] Error: {e}")
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Splitter
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_splitter(gr.basic_block):
          def __init__(self, num_duplicates=10):
              # Default num_duplicates set to 10 to match your transmitter image
              gr.basic_block.__init__(self,
                  name="PDU Splitter",
                  in_sig=None,
                  out_sig=None)
              
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # Ensure we are handling a PDU
              if pmt.is_pdu(msg):
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # Convert PMT vector to Python list/tuple of bytes
                  data = pmt.u8vector_elements(vector_data)
                  total_len = len(data)
                  
                  # Validation: The total length must be divisible by N
                  if total_len == 0 or (total_len % self.n != 0):
                      # If the packet size is wrong (likely due to noise shifting the header),
                      # we cannot safely split it. Drop it.
                      return

                  # Calculate the size of one sub-packet (Payload + CRC)
                  chunk_len = total_len // self.n
                  
                  # Loop N times to slice and send each copy
                  for i in range(self.n):
                      start = i * chunk_len
                      end = start + chunk_len
                      
                      # Extract the slice
                      sub_packet = data[start:end]
                      
                      # Create new PMT vector
                      out_vector = pmt.init_u8vector(len(sub_packet), sub_packet)
                      
                      # Create new PDU (preserving original metadata)
                      out_msg = pmt.cons(meta, out_vector)
                      
                      # Send to output
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: num_duplicates
  states: {}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Debug Logger
      Function: Prints received ACK details to the console.
      Input: Expects PDU with payload [MsgID, RN] from Address Filter (ack_out).
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import datetime

      class ack_logger(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="ACK Debug Logger",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def get_timestamp(self):
              return datetime.datetime.now().strftime("%H:%M:%S")

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  
                  # The 'ack_out' port from Address Filter sends a PDU of 2 bytes: [MsgID, RN]
                  if pmt.is_u8vector(payload):
                      data = list(pmt.u8vector_elements(payload))
                      
                      if len(data) >= 2:
                          msg_id = data[0]
                          rn_num = data[1]
                          timestamp = self.get_timestamp()
                          
                          print(f"[{timestamp}] [ACK RECV] Received ACK for MsgID: {msg_id}, Requesting Next Seq: {rn_num}")
                      else:
                          print(f"[ACK Logger] Warning: Received short ACK payload (<2 bytes)")
                  
              except Exception as e:
                  print(f"[ACK Logger] Error: {e}")
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Advanced Packetizer (Fragmentation & Priority & Delay)
      Packet Structure (12B Header + Payload):
      [Dst(4) | Src(4) | PktType(1) | MsgID(1) | SeqNum(1) | Prio(1) | Payload(N)]
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import math
      import time

      class AdvancedPacketizer(gr.basic_block):
          def __init__(self, payload_len=48, delay=0.05):
              gr.basic_block.__init__(self,
                  name="Advanced Packetizer",
                  in_sig=None,
                  out_sig=None)
              
              self.payload_len = payload_len
              self.delay = delay      # Delay in seconds
              self.msg_id_counter = 0 
              
              # Protocol Constants
              self.TYPE_MSG = ord('M') 
              self.SEQ_EOM  = 99       

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def parse_ip(self, ip_str):
              try:
                  return [int(x) for x in ip_str.strip().split('.')]
              except:
                  return [0, 0, 0, 0]

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  if pmt.is_symbol(payload_pmt):
                      full_text = pmt.symbol_to_string(payload_pmt)
                  elif pmt.is_u8vector(payload_pmt):
                      u8_list = pmt.u8vector_elements(payload_pmt)
                      full_text = "".join([chr(x) for x in u8_list])
                  else:
                      full_text = str(payload_pmt)
              except Exception as e:
                  print(f"[Packetizer] Input Error: {e}")
                  return

              try:
                  if " >> " not in full_text:
                      return
                      
                  meta_part, msg_content = full_text.split(" >> ", 1)
                  
                  src_str = meta_part.split("SRC:")[1].split(" ")[0]
                  src_bytes = self.parse_ip(src_str)
                  
                  dst_str = meta_part.split("IP:")[1].split(" ")[0]
                  dst_bytes = self.parse_ip(dst_str)
                  
                  if "MSG:[E]" in meta_part:
                      prio_byte = ord('E')
                  else:
                      prio_byte = ord('N')

              except Exception as e:
                  print(f"[Packetizer] Parsing Logic Error: {e}")
                  return

              # --- FRAGMENTATION ---
              full_payload_bytes = [ord(c) for c in msg_content]
              total_len = len(full_payload_bytes)
              
              if total_len == 0:
                  num_chunks = 1
              else:
                  num_chunks = math.ceil(total_len / self.payload_len)

              if num_chunks > 98:
                  num_chunks = 98

              # --- LOOP THROUGH CHUNKS ---
              for i in range(num_chunks):
                  start = i * self.payload_len
                  end = start + self.payload_len
                  chunk_data = full_payload_bytes[start:end]
                  
                  current_len = len(chunk_data)
                  if current_len < self.payload_len:
                      padding = [0] * (self.payload_len - current_len)
                      chunk_data = chunk_data + padding
                  
                  # Header Construction
                  header = []
                  header.extend(dst_bytes)            # Dst Addr
                  header.extend(src_bytes)            # Src Addr
                  header.append(self.TYPE_MSG)        # Type
                  header.append(self.msg_id_counter)  # Msg ID
                  header.append(i)                    # Seq Num
                  header.append(prio_byte)            # Priority
                  
                  final_packet = header + chunk_data
                  
                  self.send_pdu(final_packet)
                  
                  # Time Delay
                  time.sleep(self.delay) 

              # --- SEND EOM PACKET ---
              eom_header = []
              eom_header.extend(dst_bytes)
              eom_header.extend(src_bytes)
              eom_header.append(self.TYPE_MSG)
              eom_header.append(self.msg_id_counter)
              eom_header.append(self.SEQ_EOM)         # Seq Num 99
              eom_header.append(prio_byte)
              
              # --- NEW: Fill payload with 99s ---
              eom_payload = [99] * self.payload_len
              eom_packet = eom_header + eom_payload
              
              self.send_pdu(eom_packet)
              
              print(f"[Packetizer] Sent MsgID {self.msg_id_counter} in {num_chunks} chunks.")
              self.msg_id_counter = (self.msg_id_counter + 1) % 256

          def send_pdu(self, packet_list):
              out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet_list), packet_list))
              self.message_port_pub(pmt.intern("out"), out_pmt)
    delay: '0.1'
    payload_len: '32'
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Advanced Packetizer (Fragmentation & Priority & Delay)
      Packet Structure (12B Header + Payload):
      [Dst(4) | Src(4) | PktType(1) | MsgID(1) | SeqNum(1) | Prio(1) | Payload(N)]
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import math
      import time

      class AdvancedPacketizer(gr.basic_block):
          def __init__(self, payload_len=48, delay=0.05):
              gr.basic_block.__init__(self,
                  name="Advanced Packetizer",
                  in_sig=None,
                  out_sig=None)
              
              self.payload_len = payload_len
              self.delay = delay      # Delay in seconds
              self.msg_id_counter = 0 
              
              # Protocol Constants
              self.TYPE_MSG = ord('M') 
              self.SEQ_EOM  = 99       

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def parse_ip(self, ip_str):
              try:
                  return [int(x) for x in ip_str.strip().split('.')]
              except:
                  return [0, 0, 0, 0]

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  if pmt.is_symbol(payload_pmt):
                      full_text = pmt.symbol_to_string(payload_pmt)
                  elif pmt.is_u8vector(payload_pmt):
                      u8_list = pmt.u8vector_elements(payload_pmt)
                      full_text = "".join([chr(x) for x in u8_list])
                  else:
                      full_text = str(payload_pmt)
              except Exception as e:
                  print(f"[Packetizer] Input Error: {e}")
                  return

              try:
                  if " >> " not in full_text:
                      return
                      
                  meta_part, msg_content = full_text.split(" >> ", 1)
                  
                  src_str = meta_part.split("SRC:")[1].split(" ")[0]
                  src_bytes = self.parse_ip(src_str)
                  
                  dst_str = meta_part.split("IP:")[1].split(" ")[0]
                  dst_bytes = self.parse_ip(dst_str)
                  
                  if "MSG:[E]" in meta_part:
                      prio_byte = ord('E')
                  else:
                      prio_byte = ord('N')

              except Exception as e:
                  print(f"[Packetizer] Parsing Logic Error: {e}")
                  return

              # --- FRAGMENTATION ---
              full_payload_bytes = [ord(c) for c in msg_content]
              total_len = len(full_payload_bytes)
              
              if total_len == 0:
                  num_chunks = 1
              else:
                  num_chunks = math.ceil(total_len / self.payload_len)

              if num_chunks > 98:
                  num_chunks = 98

              # --- LOOP THROUGH CHUNKS ---
              for i in range(num_chunks):
                  start = i * self.payload_len
                  end = start + self.payload_len
                  chunk_data = full_payload_bytes[start:end]
                  
                  current_len = len(chunk_data)
                  if current_len < self.payload_len:
                      padding = [0] * (self.payload_len - current_len)
                      chunk_data = chunk_data + padding
                  
                  # Header Construction
                  header = []
                  header.extend(dst_bytes)            # Dst Addr
                  header.extend(src_bytes)            # Src Addr
                  header.append(self.TYPE_MSG)        # Type
                  header.append(self.msg_id_counter)  # Msg ID
                  header.append(i)                    # Seq Num
                  header.append(prio_byte)            # Priority
                  
                  final_packet = header + chunk_data
                  
                  self.send_pdu(final_packet)
                  
                  # Time Delay
                  time.sleep(self.delay) 

              # --- SEND EOM PACKET ---
              eom_header = []
              eom_header.extend(dst_bytes)
              eom_header.extend(src_bytes)
              eom_header.append(self.TYPE_MSG)
              eom_header.append(self.msg_id_counter)
              eom_header.append(self.SEQ_EOM)         # Seq Num 99
              eom_header.append(prio_byte)
              
              # --- NEW: Fill payload with 99s ---
              eom_payload = [99] * self.payload_len
              eom_packet = eom_header + eom_payload
              
              self.send_pdu(eom_packet)
              
              print(f"[Packetizer] Sent MsgID {self.msg_id_counter} in {num_chunks} chunks.")
              self.msg_id_counter = (self.msg_id_counter + 1) % 256

          def send_pdu(self, packet_list):
              out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet_list), packet_list))
              self.message_port_pub(pmt.intern("out"), out_pmt)
    delay: '0.1'
    payload_len: '32'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Queue & Storage (Strict Emergency Priority)
      Logic: 
      1. Priority Queues (Emergency > Requests > Normal)
      2. Preemption: If sending 'Normal' and 'Emergency' appears (New or Request), STOP immediately.
      3. Burst Send: Transmit Packet N times, checking for interrupts every time.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import threading

      class PDUQueueStorage(gr.basic_block):
          def __init__(self, timeout=1.0, max_retries=50):
              """
              timeout: Delay between retransmissions in a burst.
              max_retries: Number of times to send in one burst.
              """
              gr.basic_block.__init__(self,
                  name="PDU Queue & Storage",
                  in_sig=None,
                  out_sig=None)

              self.timeout = timeout
              self.max_retries = max_retries
              self.running = True

              # --- QUEUES (Strict Priority Order) ---
              self.queue_emergency = []  # 1. New Emergency Packets
              self.req_emergency = []    # 2. Emergency Retransmissions (triggered by ACKs)
              self.req_normal = []       # 3. Normal Retransmissions
              self.queue_normal = []     # 4. New Normal Packets
              self.storage = []          # 5. Persistent Storage (All un-ACKed packets)
              
              self.lock = threading.Lock()

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("rn_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("rn_in"), self.handle_rn)

              self.worker_thread = threading.Thread(target=self.process_loop, daemon=True)
              self.worker_thread.start()

          def get_header_info(self, u8_list):
              try:
                  # Header: [Dst(4)|Src(4)|Type(1)|MsgID(1)|Seq(1)|Prio(1)]
                  msg_id = u8_list[9]
                  seq_num = u8_list[10]
                  prio_byte = u8_list[11]
                  return msg_id, seq_num, prio_byte
              except:
                  return 0, 0, 0

          def handle_pdu(self, msg):
              """Handle Incoming New Packet from User"""
              with self.lock:
                  payload = pmt.cdr(msg)
                  u8_list = list(pmt.u8vector_elements(payload))
                  _, _, prio_byte = self.get_header_info(u8_list)
                  
                  # STRICT SORTING
                  if prio_byte == ord('E'):
                      self.queue_emergency.append(u8_list)
                      # print("[Queue] New EMERGENCY Packet Received!")
                  else:
                      self.queue_normal.append(u8_list)

          def handle_rn(self, msg):
              """Handle Feedback (ACK/Request) from Receiver"""
              with self.lock:
                  try:
                      payload = pmt.cdr(msg)
                      rn_data = list(pmt.u8vector_elements(payload))
                      
                      if len(rn_data) < 2: return
                      
                      req_msg_id = rn_data[0]
                      req_seq_num = rn_data[1]
                      
                      # 1. CLEANUP (Cumulative ACK): Remove successfully received packets
                      # (Same MsgID but LOWER SeqNum means receiver has them)
                      self.storage = [p for p in self.storage if not (p['msg_id'] == req_msg_id and p['seq'] < req_seq_num)]
                      
                      # 2. RETRANSMISSION REQUEST (NACK):
                      # Receiver is asking for 'req_seq_num'. Find it and queue it ASAP.
                      for item in self.storage:
                          if item['msg_id'] == req_msg_id and item['seq'] == req_seq_num:
                              pdu_copy = list(item['pdu'])
                              
                              # PRIORITY CHECK: Is the missing packet Emergency?
                              if item['prio'] == ord('E'):
                                  # HIGH PRIORITY REQUEST
                                  self.req_emergency.append(pdu_copy)
                                  # print(f"[Queue] Emergency Retransmission Requested! (Seq {req_seq_num})")
                              else:
                                  self.req_normal.append(pdu_copy)
                              break 
                  except Exception as e:
                      print(f"[Queue] RN Error: {e}")

          def send_pdu_burst(self, pdu_list, is_new=False):
              """
              Sends packet multiple times.
              CRITICAL: Checks for Emergency Interrupts before every single send.
              """
              
              # 1. ADD TO STORAGE (If New)
              if is_new:
                  with self.lock:
                      msg_id, seq_num, prio = self.get_header_info(pdu_list)
                      exists = any(p['msg_id'] == msg_id and p['seq'] == seq_num for p in self.storage)
                      if not exists:
                          self.storage.append({
                              'pdu': pdu_list,
                              'msg_id': msg_id,
                              'seq': seq_num,
                              'prio': prio
                          })

              # 2. BURST LOOP
              for i in range(self.max_retries):
                  
                  # --- CHECK A: HAS IT BEEN ACKED? ---
                  # If receiver got it, stop wasting time.
                  with self.lock:
                      msg_id, seq_num, _ = self.get_header_info(pdu_list)
                      still_exists = any(p['msg_id'] == msg_id and p['seq'] == seq_num for p in self.storage)
                      if not still_exists:
                          return # Packet cleared, stop burst.

                  # --- CHECK B: EMERGENCY INTERRUPT ---
                  # If we are sending Normal, but Emergency work appeared -> ABORT.
                  if self.check_priority_interrupt(current_pdu=pdu_list):
                      return # Stop this burst immediately to handle Emergency.

                  # --- SEND ---
                  out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(pdu_list), pdu_list))
                  self.message_port_pub(pmt.intern("pdu_out"), out_pmt)
                  
                  # --- WAIT ---
                  time.sleep(self.timeout)

          def check_priority_interrupt(self, current_pdu):
              """Returns True if a higher priority task exists"""
              _, _, prio = self.get_header_info(current_pdu)
              
              # Only NORMAL packets can be interrupted
              if prio == ord('N'):
                  with self.lock:
                      # If ANY Emergency task (New or Request) is waiting...
                      if len(self.queue_emergency) > 0 or len(self.req_emergency) > 0:
                          # print("[Queue] Normal Burst INTERRUPTED for Emergency!")
                          return True
              return False

          def process_loop(self):
              while self.running:
                  target_pdu = None
                  is_new = False
                  
                  # --- 1. CHECK QUEUES (Highest to Lowest) ---
                  # Always check Emergency first.
                  with self.lock:
                      if len(self.queue_emergency) > 0:
                          target_pdu = self.queue_emergency.pop(0)
                          is_new = True
                      elif len(self.req_emergency) > 0:
                          target_pdu = self.req_emergency.pop(0)
                          is_new = False
                      elif len(self.req_normal) > 0:
                          target_pdu = self.req_normal.pop(0)
                          is_new = False
                      elif len(self.queue_normal) > 0:
                          target_pdu = self.queue_normal.pop(0)
                          is_new = True
                  
                  # If we found something in the high-priority queues, handle it
                  if target_pdu:
                      self.send_pdu_burst(target_pdu, is_new)
                      continue # Restart loop to check for more Emergency items
                  
                  # --- 2. STORAGE LOOP (Round Robin / Idle) ---
                  # If queues are empty, we cycle through storage (re-sending un-ACKed items)
                  with self.lock:
                      storage_snapshot = list(self.storage)
                  
                  if len(storage_snapshot) == 0:
                      time.sleep(0.1) 
                      continue

                  for item in storage_snapshot:
                      # Before starting a stored item burst, check queues again
                      with self.lock:
                          if len(self.queue_emergency) > 0 or len(self.queue_normal) > 0 or \
                             len(self.req_emergency) > 0 or len(self.req_normal) > 0:
                              break # Break out of storage loop to handle new queue items
                      
                      # Perform Burst
                      self.send_pdu_burst(item['pdu'], is_new=False)
    max_retries: '20'
    timeout: '1'
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Queue & Storage (Burst ARQ)
      Logic: 
      1. Priority Queues (Emergency > Requests > Normal)
      2. Burst Send: Transmit Packet N times (Timeout interval).
      3. Storage Loop: Iterate stored packets and Burst Send them repeatedly.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import threading

      class PDUQueueStorage(gr.basic_block):
          def __init__(self, timeout=1.0, max_retries=5):
              """
              timeout: Delay between retransmissions in a burst.
              max_retries: Number of times to send in one burst (e.g., 5 -> A,A,A,A,A).
              """
              gr.basic_block.__init__(self,
                  name="PDU Queue & Storage",
                  in_sig=None,
                  out_sig=None)

              self.timeout = timeout
              self.max_retries = max_retries
              self.running = True

              # --- QUEUES ---
              self.queue_emergency = []  # 1. New Emergency
              self.req_emergency = []    # 2. Emergency Requests
              self.req_normal = []       # 3. Normal Requests
              self.queue_normal = []     # 4. New Normal
              self.storage = []          # 5. Persistent Storage
              
              self.lock = threading.Lock()

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("rn_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("rn_in"), self.handle_rn)

              self.worker_thread = threading.Thread(target=self.process_loop, daemon=True)
              self.worker_thread.start()

          def get_header_info(self, u8_list):
              try:
                  # Header: [Dst(4)|Src(4)|Type(1)|MsgID(1)|Seq(1)|Prio(1)]
                  msg_id = u8_list[9]
                  seq_num = u8_list[10]
                  prio_byte = u8_list[11]
                  return msg_id, seq_num, prio_byte
              except:
                  return 0, 0, 0

          def handle_pdu(self, msg):
              """Handle Incoming New Packet"""
              with self.lock:
                  payload = pmt.cdr(msg)
                  u8_list = list(pmt.u8vector_elements(payload))
                  _, _, prio_byte = self.get_header_info(u8_list)
                  
                  if prio_byte == ord('E'):
                      self.queue_emergency.append(u8_list)
                  else:
                      self.queue_normal.append(u8_list)

          def handle_rn(self, msg):
              """Handle Retransmission Request (ACK/NACK)"""
              with self.lock:
                  try:
                      payload = pmt.cdr(msg)
                      rn_data = list(pmt.u8vector_elements(payload))
                      req_msg_id = rn_data[0]
                      req_seq_num = rn_data[1]
                      
                      # 1. Cumulative ACK: Delete all packets with Same MsgID but LOWER SeqNum
                      # (Assuming they were received successfully)
                      self.storage = [p for p in self.storage if not (p['msg_id'] == req_msg_id and p['seq'] < req_seq_num)]
                      
                      # 2. Specific Request: Find target and queue for Priority Burst
                      for item in self.storage:
                          if item['msg_id'] == req_msg_id and item['seq'] == req_seq_num:
                              pdu_copy = list(item['pdu'])
                              if item['prio'] == ord('E'):
                                  self.req_emergency.append(pdu_copy)
                              else:
                                  self.req_normal.append(pdu_copy)
                              break 
                  except Exception as e:
                      print(f"[Queue] RN Error: {e}")

          def send_pdu_burst(self, pdu_list, is_new=False):
              """Helper to send a packet 'max_retries' times"""
              
              # If it's a NEW packet, we must add it to storage first
              # so it doesn't get lost if we crash or move on.
              if is_new:
                  with self.lock:
                      msg_id, seq_num, prio = self.get_header_info(pdu_list)
                      # Check duplicate
                      exists = any(p['msg_id'] == msg_id and p['seq'] == seq_num for p in self.storage)
                      if not exists:
                          self.storage.append({
                              'pdu': pdu_list,
                              'msg_id': msg_id,
                              'seq': seq_num,
                              'prio': prio
                          })

              # --- BURST TRANSMISSION (A, A, A, A, A...) ---
              for i in range(self.max_retries):
                  # Check for High Priority Interrupts
                  if self.check_priority_interrupt(current_pdu=pdu_list):
                      return # Stop this burst to handle Emergency

                  # Check if Packet was ACKed (Removed from storage) mid-burst
                  # (Only relevant if we are retransmitting from storage)
                  if not is_new:
                      with self.lock:
                          msg_id, seq_num, _ = self.get_header_info(pdu_list)
                          still_exists = any(p['msg_id'] == msg_id and p['seq'] == seq_num for p in self.storage)
                          if not still_exists:
                              return # Stop burst, it was ACKed!

                  # Send
                  out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(pdu_list), pdu_list))
                  self.message_port_pub(pmt.intern("pdu_out"), out_pmt)
                  
                  # Wait
                  time.sleep(self.timeout)

          def check_priority_interrupt(self, current_pdu):
              """Returns True if a higher priority packet arrived"""
              # If we are sending Normal, check for Emergency
              _, _, prio = self.get_header_info(current_pdu)
              if prio == ord('N'):
                  with self.lock:
                      if len(self.queue_emergency) > 0 or len(self.req_emergency) > 0:
                          return True
              return False

          def process_loop(self):
              while self.running:
                  target_pdu = None
                  is_new = False
                  
                  # --- 1. CHECK QUEUES (Highest to Lowest) ---
                  with self.lock:
                      if len(self.queue_emergency) > 0:
                          target_pdu = self.queue_emergency.pop(0)
                          is_new = True
                      elif len(self.req_emergency) > 0:
                          target_pdu = self.req_emergency.pop(0)
                          is_new = False
                      elif len(self.req_normal) > 0:
                          target_pdu = self.req_normal.pop(0)
                          is_new = False
                      elif len(self.queue_normal) > 0:
                          target_pdu = self.queue_normal.pop(0)
                          is_new = True
                  
                  if target_pdu:
                      self.send_pdu_burst(target_pdu, is_new)
                      continue # Loop back to check queues again
                  
                  # --- 2. STORAGE LOOP (Round Robin) ---
                  # If Queues are empty, iterate through storage
                  # We copy the list to avoid modification issues during iteration
                  with self.lock:
                      storage_snapshot = list(self.storage)
                  
                  if len(storage_snapshot) == 0:
                      time.sleep(0.1) # Nothing to do
                      continue

                  for item in storage_snapshot:
                      # Before starting burst, check if Queues got new data
                      with self.lock:
                          if len(self.queue_emergency) > 0 or len(self.queue_normal) > 0 or \
                             len(self.req_emergency) > 0 or len(self.req_normal) > 0:
                              break # Break storage loop to handle new data
                      
                      # Perform Burst for this stored item
                      self.send_pdu_burst(item['pdu'], is_new=False)
    max_retries: '20'
    timeout: '1'
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Filter (Debounce)
      Function: 
      1. Filters out rapid, redundant ACKs (ACK Bursts).
      2. Allows the same ACK to pass only after a 'timeout' (to handle lost feedback).
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class ack_filter(gr.basic_block):
          def __init__(self, timeout=2.0):
              """
              timeout: Time (seconds) to ignore identical ACKs after passing one.
                       Should be slightly larger than the Receiver's Burst Duration.
              """
              gr.basic_block.__init__(self,
                  name="ACK Filter (Debounce)",
                  in_sig=None,
                  out_sig=None)

              self.timeout = timeout
              
              # State Variables
              self.last_msg_id = -1
              self.last_rn = -1
              self.last_pass_time = 0.0

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  
                  # The input is [MsgID, RN] from Address Filter
                  if pmt.is_u8vector(payload):
                      data = list(pmt.u8vector_elements(payload))
                      
                      if len(data) >= 2:
                          msg_id = data[0]
                          rn_num = data[1]
                          
                          current_time = time.time()
                          
                          # --- LOGIC START ---
                          
                          # Condition 1: Is this a DIFFERENT ACK?
                          is_different = (msg_id != self.last_msg_id) or (rn_num != self.last_rn)
                          
                          # Condition 2: Has the timeout expired?
                          time_diff = current_time - self.last_pass_time
                          is_expired = time_diff > self.timeout
                          
                          if is_different or is_expired:
                              # PASS IT
                              self.last_msg_id = msg_id
                              self.last_rn = rn_num
                              self.last_pass_time = current_time
                              
                              self.message_port_pub(pmt.intern("pdu_out"), msg)
                              # Optional Debug
                              # print(f"[ACK Filter] Passing ACK {msg_id}:{rn_num}")
                              
                          else:
                              # DROP IT (It's a repeat within timeout)
                              pass 

              except Exception as e:
                  print(f"[ACK Filter] Error: {e}")
    timeout: '0.01'
  states: {}
- name: epy_block_6_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Filter (Debounce)
      Function: 
      1. Filters out rapid, redundant ACKs (ACK Bursts).
      2. Allows the same ACK to pass only after a 'timeout' (to handle lost feedback).
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class ack_filter(gr.basic_block):
          def __init__(self, timeout=2.0):
              """
              timeout: Time (seconds) to ignore identical ACKs after passing one.
                       Should be slightly larger than the Receiver's Burst Duration.
              """
              gr.basic_block.__init__(self,
                  name="ACK Filter (Debounce)",
                  in_sig=None,
                  out_sig=None)

              self.timeout = timeout
              
              # State Variables
              self.last_msg_id = -1
              self.last_rn = -1
              self.last_pass_time = 0.0

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  
                  # The input is [MsgID, RN] from Address Filter
                  if pmt.is_u8vector(payload):
                      data = list(pmt.u8vector_elements(payload))
                      
                      if len(data) >= 2:
                          msg_id = data[0]
                          rn_num = data[1]
                          
                          current_time = time.time()
                          
                          # --- LOGIC START ---
                          
                          # Condition 1: Is this a DIFFERENT ACK?
                          is_different = (msg_id != self.last_msg_id) or (rn_num != self.last_rn)
                          
                          # Condition 2: Has the timeout expired?
                          time_diff = current_time - self.last_pass_time
                          is_expired = time_diff > self.timeout
                          
                          if is_different or is_expired:
                              # PASS IT
                              self.last_msg_id = msg_id
                              self.last_rn = rn_num
                              self.last_pass_time = current_time
                              
                              self.message_port_pub(pmt.intern("pdu_out"), msg)
                              # Optional Debug
                              # print(f"[ACK Filter] Passing ACK {msg_id}:{rn_num}")
                              
                          else:
                              # DROP IT (It's a repeat within timeout)
                              pass 

              except Exception as e:
                  print(f"[ACK Filter] Error: {e}")
    timeout: '1'
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Sequence & Msg Decoder (Fixed Void Msgs)
      Function:
      1. Reassembles messages from packets.
      2. Tracks Sequence Numbers (RN).
      3. Sends 'Draft ACKs' to the ACK Generator.
      4. Outputs Reassembled Text to GUI.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct

      class sequence_decoder(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Sequence & Msg Decoder",
                  in_sig=None,
                  out_sig=None)

              # Inputs/Outputs
              self.message_port_register_in(pmt.intern("pdu_in")) 
              self.message_port_register_out(pmt.intern("to_ack")) # To ACK Generator
              self.message_port_register_out(pmt.intern("to_app")) # To GUI

              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              self.sessions = {}

          def parse_header(self, u8_list):
              dst_ip = tuple(u8_list[0:4])
              src_ip = tuple(u8_list[4:8])
              pkt_type = u8_list[8]
              msg_id   = u8_list[9]
              seq_num  = u8_list[10]
              prio     = u8_list[11]
              payload  = u8_list[12:]
              return dst_ip, src_ip, pkt_type, msg_id, seq_num, prio, payload

          def send_ack(self, dst_ip_me, src_ip_sender, msg_id, rn_request, prio):
              """
              Prepares 'Draft' ACK.
              Format: [Dst=Me | Src=Sender | Type=M | MsgID | RN | Prio]
              NOTE: addresses are NOT swapped here. ACK Generator will do it.
              """
              ack_header = []
              ack_header.extend(list(dst_ip_me))      # Keep Dst = Me
              ack_header.extend(list(src_ip_sender))  # Keep Src = Sender
              ack_header.append(ord('M'))             # Type placeholder (Generator sets 'A')
              ack_header.append(msg_id)
              ack_header.append(rn_request)           # The requested SN (RN)
              ack_header.append(prio)
              
              padding = [0] * 16 
              ack_packet = ack_header + padding
              
              out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(ack_packet), ack_packet))
              self.message_port_pub(pmt.intern("to_ack"), out_pmt)

          def handle_msg(self, msg):
              try:
                  pdu_content = pmt.cdr(msg)
                  u8_list = list(pmt.u8vector_elements(pdu_content))
                  if len(u8_list) < 12: return

                  dst_ip, src_ip, pkt_type, msg_id, seq_num, prio, payload = self.parse_header(u8_list)
                  session_key = (src_ip, msg_id)

                  if session_key not in self.sessions:
                      self.sessions[session_key] = {'rn': 0, 'buffer': {}, 'eom_received': False}
                  state = self.sessions[session_key]

                  if seq_num == 99:
                      state['eom_received'] = True

                  # Case 1: Old Packet (Already have it) -> Ack current RN
                  if seq_num < state['rn'] and seq_num != 99:
                      self.send_ack(dst_ip, src_ip, msg_id, state['rn'], prio)
                      return

                  # Case 2: New Packet -> Store it
                  if seq_num != 99:
                      state['buffer'][seq_num] = payload

                  # Advance RN (Cumulative)
                  while state['rn'] in state['buffer']:
                      state['rn'] += 1

                  # --- COMPLETION CHECK (UPDATED) ---
                  is_complete = False
                  if state['eom_received']:
                      # FIX: Ensure we actually have data (rn > 0) to avoid void messages
                      if len(state['buffer']) == state['rn'] and state['rn'] > 0:
                          is_complete = True

                  if is_complete:
                      # Send Success (RN=100)
                      self.send_ack(dst_ip, src_ip, msg_id, 100, prio)
                      self.reassemble_and_send(state['buffer'], src_ip, dst_ip, prio)
                      del self.sessions[session_key]
                  else:
                      # Request Next Needed Packet (RN)
                      self.send_ack(dst_ip, src_ip, msg_id, state['rn'], prio)

              except Exception as e:
                  print(f"[Decoder] Error: {e}")

          def reassemble_and_send(self, buffer, src_ip, dst_ip, prio):
              try:
                  sorted_seqs = sorted(buffer.keys())
                  full_msg_bytes = []
                  for s in sorted_seqs:
                      full_msg_bytes.extend(buffer[s])

                  clean_bytes = [b for b in full_msg_bytes if b != 0]
                  msg_text = "".join([chr(b) for b in clean_bytes])

                  src_str = ".".join(map(str, src_ip))
                  dst_str = ".".join(map(str, dst_ip))
                  prio_char = chr(prio) 
                  
                  # Format: [INFO] SRC:x.x.x.x IP:x.x.x.x MSG:[E] >> Hello
                  final_string = f"[INFO] SRC:{src_str} IP:{dst_str} MSG:[{prio_char}] >> {msg_text}"
                  
                  out_pmt = pmt.cons(pmt.PMT_NIL, pmt.string_to_symbol(final_string))
                  self.message_port_pub(pmt.intern("to_app"), out_pmt)
                  print(f"[Decoder] Reassembled: {final_string}")

              except Exception as e:
                  print(f"[Decoder] Reassembly Error: {e}")
  states: {}
- name: epy_block_7_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Sequence & Msg Decoder (Fixed Void Msgs)
      Function:
      1. Reassembles messages from packets.
      2. Tracks Sequence Numbers (RN).
      3. Sends 'Draft ACKs' to the ACK Generator.
      4. Outputs Reassembled Text to GUI.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct

      class sequence_decoder(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Sequence & Msg Decoder",
                  in_sig=None,
                  out_sig=None)

              # Inputs/Outputs
              self.message_port_register_in(pmt.intern("pdu_in")) 
              self.message_port_register_out(pmt.intern("to_ack")) # To ACK Generator
              self.message_port_register_out(pmt.intern("to_app")) # To GUI

              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              self.sessions = {}

          def parse_header(self, u8_list):
              dst_ip = tuple(u8_list[0:4])
              src_ip = tuple(u8_list[4:8])
              pkt_type = u8_list[8]
              msg_id   = u8_list[9]
              seq_num  = u8_list[10]
              prio     = u8_list[11]
              payload  = u8_list[12:]
              return dst_ip, src_ip, pkt_type, msg_id, seq_num, prio, payload

          def send_ack(self, dst_ip_me, src_ip_sender, msg_id, rn_request, prio):
              """
              Prepares 'Draft' ACK.
              Format: [Dst=Me | Src=Sender | Type=M | MsgID | RN | Prio]
              NOTE: addresses are NOT swapped here. ACK Generator will do it.
              """
              ack_header = []
              ack_header.extend(list(dst_ip_me))      # Keep Dst = Me
              ack_header.extend(list(src_ip_sender))  # Keep Src = Sender
              ack_header.append(ord('M'))             # Type placeholder (Generator sets 'A')
              ack_header.append(msg_id)
              ack_header.append(rn_request)           # The requested SN (RN)
              ack_header.append(prio)
              
              padding = [0] * 16 
              ack_packet = ack_header + padding
              
              out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(ack_packet), ack_packet))
              self.message_port_pub(pmt.intern("to_ack"), out_pmt)

          def handle_msg(self, msg):
              try:
                  pdu_content = pmt.cdr(msg)
                  u8_list = list(pmt.u8vector_elements(pdu_content))
                  if len(u8_list) < 12: return

                  dst_ip, src_ip, pkt_type, msg_id, seq_num, prio, payload = self.parse_header(u8_list)
                  session_key = (src_ip, msg_id)

                  if session_key not in self.sessions:
                      self.sessions[session_key] = {'rn': 0, 'buffer': {}, 'eom_received': False}
                  state = self.sessions[session_key]

                  if seq_num == 99:
                      state['eom_received'] = True

                  # Case 1: Old Packet (Already have it) -> Ack current RN
                  if seq_num < state['rn'] and seq_num != 99:
                      self.send_ack(dst_ip, src_ip, msg_id, state['rn'], prio)
                      return

                  # Case 2: New Packet -> Store it
                  if seq_num != 99:
                      state['buffer'][seq_num] = payload

                  # Advance RN (Cumulative)
                  while state['rn'] in state['buffer']:
                      state['rn'] += 1

                  # --- COMPLETION CHECK (UPDATED) ---
                  is_complete = False
                  if state['eom_received']:
                      # FIX: Ensure we actually have data (rn > 0) to avoid void messages
                      if len(state['buffer']) == state['rn'] and state['rn'] > 0:
                          is_complete = True

                  if is_complete:
                      # Send Success (RN=100)
                      self.send_ack(dst_ip, src_ip, msg_id, 100, prio)
                      self.reassemble_and_send(state['buffer'], src_ip, dst_ip, prio)
                      del self.sessions[session_key]
                  else:
                      # Request Next Needed Packet (RN)
                      self.send_ack(dst_ip, src_ip, msg_id, state['rn'], prio)

              except Exception as e:
                  print(f"[Decoder] Error: {e}")

          def reassemble_and_send(self, buffer, src_ip, dst_ip, prio):
              try:
                  sorted_seqs = sorted(buffer.keys())
                  full_msg_bytes = []
                  for s in sorted_seqs:
                      full_msg_bytes.extend(buffer[s])

                  clean_bytes = [b for b in full_msg_bytes if b != 0]
                  msg_text = "".join([chr(b) for b in clean_bytes])

                  src_str = ".".join(map(str, src_ip))
                  dst_str = ".".join(map(str, dst_ip))
                  prio_char = chr(prio) 
                  
                  # Format: [INFO] SRC:x.x.x.x IP:x.x.x.x MSG:[E] >> Hello
                  final_string = f"[INFO] SRC:{src_str} IP:{dst_str} MSG:[{prio_char}] >> {msg_text}"
                  
                  out_pmt = pmt.cons(pmt.PMT_NIL, pmt.string_to_symbol(final_string))
                  self.message_port_pub(pmt.intern("to_app"), out_pmt)
                  print(f"[Decoder] Reassembled: {final_string}")

              except Exception as e:
                  print(f"[Decoder] Reassembly Error: {e}")
  states: {}
- name: epy_block_7_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Address & Type Filter (Receiver Gatekeeper)
      Function:
      1. Filters packets based on Destination IP.
      2. Sorts Traffic:
         - Type 'M' (Message) -> pdu_out (To Depacketizer/Display)
         - Type 'A' (ACK)     -> ack_out (To PDU Storage to clear buffer)
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import socket

      class addr_type_filter(gr.basic_block):
          def __init__(self, my_ip="192.168.1.20"):
              """
              my_ip: The IP address of THIS receiver. 
                     Packets not destined for this IP will be dropped.
              """
              gr.basic_block.__init__(self,
                  name="Address & Type Filter",
                  in_sig=None,
                  out_sig=None)

              self.my_ip_str = my_ip
              
              # Convert IP string to 4-byte list for comparison
              try:
                  self.my_ip_bytes = list(socket.inet_aton(self.my_ip_str))
              except OSError:
                  print(f"[Filter] Error: Invalid IP {my_ip}")
                  self.my_ip_bytes = [0, 0, 0, 0]

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              
              # Output 1: Valid Messages (Goes to Depacketizer)
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Output 2: Valid ACKs (Goes back to Transmitter's PDU Storage)
              self.message_port_register_out(pmt.intern("ack_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  data_bytes = list(pmt.u8vector_elements(payload))
                  
                  # --- 1. Safety Check (Min Header Size) ---
                  # Header is 12 bytes. If less, it's garbage.
                  if len(data_bytes) < 12:
                      return

                  # --- 2. Check Destination Address (Bytes 0-3) ---
                  dest_received = data_bytes[0:4]
                  
                  if dest_received != self.my_ip_bytes:
                      # Packet is not for me -> Drop it
                      return

                  # --- 3. Extract Type Info ---
                  # Header: [Dst(4) | Src(4) | Type(1) | MsgID(1) | Seq(1) | Prio(1)]
                  # Indices: 0-3      4-7      8         9         10      11
                  
                  pkt_type = data_bytes[8]
                  msg_id   = data_bytes[9]
                  seq_or_rn = data_bytes[10] # SeqNum for Msg, RN for ACK

                  # --- 4. Logic Branch ---
                  
                  # === CASE: MESSAGE ('M') ===
                  if pkt_type == ord('M'):
                      # User Requirement: Send the WHOLE PDU to pdu_out
                      self.message_port_pub(pmt.intern("pdu_out"), msg)

                  # === CASE: ACKNOWLEDGMENT ('A') ===
                  elif pkt_type == ord('A'):
                      # User Requirement: Send MsgID and RN to ack_out
                      # The PDU Storage block expects a PDU payload of [MsgID, RN]
                      
                      ack_payload = [msg_id, seq_or_rn]
                      
                      # Create PDU
                      out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(2, ack_payload))
                      self.message_port_pub(pmt.intern("ack_out"), out_pmt)
                      
                      # print(f"[Filter] Received ACK for Msg {msg_id}, RN {seq_or_rn}")

              except Exception as e:
                  print(f"[Filter] Error: {e}")
    my_ip: '"192.168.1.11"'
  states: {}
- name: epy_block_7_1_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Address & Type Filter (Receiver Gatekeeper)
      Function:
      1. Filters packets based on Destination IP.
      2. Sorts Traffic:
         - Type 'M' (Message) -> pdu_out (To Depacketizer/Display)
         - Type 'A' (ACK)     -> ack_out (To PDU Storage to clear buffer)
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import socket

      class addr_type_filter(gr.basic_block):
          def __init__(self, my_ip="192.168.1.20"):
              """
              my_ip: The IP address of THIS receiver. 
                     Packets not destined for this IP will be dropped.
              """
              gr.basic_block.__init__(self,
                  name="Address & Type Filter",
                  in_sig=None,
                  out_sig=None)

              self.my_ip_str = my_ip
              
              # Convert IP string to 4-byte list for comparison
              try:
                  self.my_ip_bytes = list(socket.inet_aton(self.my_ip_str))
              except OSError:
                  print(f"[Filter] Error: Invalid IP {my_ip}")
                  self.my_ip_bytes = [0, 0, 0, 0]

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              
              # Output 1: Valid Messages (Goes to Depacketizer)
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Output 2: Valid ACKs (Goes back to Transmitter's PDU Storage)
              self.message_port_register_out(pmt.intern("ack_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  data_bytes = list(pmt.u8vector_elements(payload))
                  
                  # --- 1. Safety Check (Min Header Size) ---
                  # Header is 12 bytes. If less, it's garbage.
                  if len(data_bytes) < 12:
                      return

                  # --- 2. Check Destination Address (Bytes 0-3) ---
                  dest_received = data_bytes[0:4]
                  
                  if dest_received != self.my_ip_bytes:
                      # Packet is not for me -> Drop it
                      return

                  # --- 3. Extract Type Info ---
                  # Header: [Dst(4) | Src(4) | Type(1) | MsgID(1) | Seq(1) | Prio(1)]
                  # Indices: 0-3      4-7      8         9         10      11
                  
                  pkt_type = data_bytes[8]
                  msg_id   = data_bytes[9]
                  seq_or_rn = data_bytes[10] # SeqNum for Msg, RN for ACK

                  # --- 4. Logic Branch ---
                  
                  # === CASE: MESSAGE ('M') ===
                  if pkt_type == ord('M'):
                      # User Requirement: Send the WHOLE PDU to pdu_out
                      self.message_port_pub(pmt.intern("pdu_out"), msg)

                  # === CASE: ACKNOWLEDGMENT ('A') ===
                  elif pkt_type == ord('A'):
                      # User Requirement: Send MsgID and RN to ack_out
                      # The PDU Storage block expects a PDU payload of [MsgID, RN]
                      
                      ack_payload = [msg_id, seq_or_rn]
                      
                      # Create PDU
                      out_pmt = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(2, ack_payload))
                      self.message_port_pub(pmt.intern("ack_out"), out_pmt)
                      
                      # print(f"[Filter] Received ACK for Msg {msg_id}, RN {seq_or_rn}")

              except Exception as e:
                  print(f"[Filter] Error: {e}")
    my_ip: '"192.168.1.10"'
  states: {}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Generator
      Input:  [Dest=Me | Src=Sender | Type=? | MsgID | RN | Prio | Padding(00...)]
      Output: [Dest=Sender | Src=Me | Type='A' | MsgID | RN | Prio | Dummy(AA...)]
      """
      import numpy as np
      from gnuradio import gr
      import pmt

      class ack_generator(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="ACK Generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  if not pmt.is_u8vector(payload): return
                  
                  # Convert to mutable list
                  data = list(pmt.u8vector_elements(payload))
                  if len(data) < 12: return

                  # --- 1. SWAP ADDRESSES (Bounce Back) ---
                  me_ip = data[0:4] 
                  sender_ip = data[4:8] 

                  data[0:4] = sender_ip 
                  data[4:8] = me_ip 

                  # --- 2. SET PACKET TYPE TO 'A' (ACK) ---
                  data[8] = ord('A')

                  # --- 3. FILL PAYLOAD WITH DUMMY DATA (0xAA) ---
                  # Everything after the 12-byte header is payload
                  # 0xAA = 10101010 (Good for keeping bit sync active)
                  for i in range(12, len(data)):
                      data[i] = 0xAA

                  # --- 4. OUTPUT ---
                  out_pdu = pmt.init_u8vector(len(data), data)
                  out_msg = pmt.cons(pmt.PMT_NIL, out_pdu)
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)

              except Exception as e:
                  print(f"[ACK Gen] Error: {e}")
  states: {}
- name: epy_block_8_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Generator
      Input:  [Dest=Me | Src=Sender | Type=? | MsgID | RN | Prio | Padding(00...)]
      Output: [Dest=Sender | Src=Me | Type='A' | MsgID | RN | Prio | Dummy(AA...)]
      """
      import numpy as np
      from gnuradio import gr
      import pmt

      class ack_generator(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="ACK Generator",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  if not pmt.is_u8vector(payload): return
                  
                  # Convert to mutable list
                  data = list(pmt.u8vector_elements(payload))
                  if len(data) < 12: return

                  # --- 1. SWAP ADDRESSES (Bounce Back) ---
                  me_ip = data[0:4] 
                  sender_ip = data[4:8] 

                  data[0:4] = sender_ip 
                  data[4:8] = me_ip 

                  # --- 2. SET PACKET TYPE TO 'A' (ACK) ---
                  data[8] = ord('A')

                  # --- 3. FILL PAYLOAD WITH DUMMY DATA (0xAA) ---
                  # Everything after the 12-byte header is payload
                  # 0xAA = 10101010 (Good for keeping bit sync active)
                  for i in range(12, len(data)):
                      data[i] = 0xAA

                  # --- 4. OUTPUT ---
                  out_pdu = pmt.init_u8vector(len(data), data)
                  out_msg = pmt.cons(pmt.PMT_NIL, out_pdu)
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)

              except Exception as e:
                  print(f"[ACK Gen] Error: {e}")
  states: {}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Selective AES Encryptor
      Function: 
      1. Reads 12-Byte Cleartext Header.
      2. Encrypts the Payload (Bytes 12+) using AES-128 ECB.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES

      class selective_aes_encrypt(gr.basic_block):
          def __init__(self, key_str="1234567890123456"):
              gr.basic_block.__init__(self,
                  name="Selective AES Encryptor",
                  in_sig=None,
                  out_sig=None)

              # Ensure key is 16 bytes
              self.key = key_str.encode('utf-8')[:16]
              while len(self.key) < 16:
                  self.key += b'\0'

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  data = list(pmt.u8vector_elements(payload_pmt))
                  
                  # Safety Check: Header(12) + Min Block(16)
                  if len(data) < 12:
                      return

                  # 1. Split Header and Payload
                  header = data[0:12]      # Cleartext Header
                  raw_payload = data[12:]  # To Be Encrypted
                  
                  # 2. Check Padding (AES requires multiple of 16)
                  # The Advanced Packetizer *should* have done this, but we double-check.
                  remainder = len(raw_payload) % 16
                  if remainder != 0:
                      pad_len = 16 - remainder
                      raw_payload += [0] * pad_len
                  
                  # 3. Encrypt
                  cipher = AES.new(self.key, AES.MODE_ECB)
                  encrypted_bytes = cipher.encrypt(bytes(raw_payload))
                  
                  # 4. Recombine
                  final_packet = header + list(encrypted_bytes)
                  
                  # 5. Output
                  out_pdu = pmt.init_u8vector(len(final_packet), final_packet)
                  out_msg = pmt.cons(pmt.PMT_NIL, out_pdu)
                  self.message_port_pub(pmt.intern("out"), out_msg)

              except Exception as e:
                  print(f"[AES Encrypt] Error: {e}")
    key_str: '"1234567890123456"'
  states: {}
- name: epy_block_9_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Selective AES Encryptor
      Function: 
      1. Reads 12-Byte Cleartext Header.
      2. Encrypts the Payload (Bytes 12+) using AES-128 ECB.
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES

      class selective_aes_encrypt(gr.basic_block):
          def __init__(self, key_str="1234567890123456"):
              gr.basic_block.__init__(self,
                  name="Selective AES Encryptor",
                  in_sig=None,
                  out_sig=None)

              # Ensure key is 16 bytes
              self.key = key_str.encode('utf-8')[:16]
              while len(self.key) < 16:
                  self.key += b'\0'

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  data = list(pmt.u8vector_elements(payload_pmt))
                  
                  # Safety Check: Header(12) + Min Block(16)
                  if len(data) < 12:
                      return

                  # 1. Split Header and Payload
                  header = data[0:12]      # Cleartext Header
                  raw_payload = data[12:]  # To Be Encrypted
                  
                  # 2. Check Padding (AES requires multiple of 16)
                  # The Advanced Packetizer *should* have done this, but we double-check.
                  remainder = len(raw_payload) % 16
                  if remainder != 0:
                      pad_len = 16 - remainder
                      raw_payload += [0] * pad_len
                  
                  # 3. Encrypt
                  cipher = AES.new(self.key, AES.MODE_ECB)
                  encrypted_bytes = cipher.encrypt(bytes(raw_payload))
                  
                  # 4. Recombine
                  final_packet = header + list(encrypted_bytes)
                  
                  # 5. Output
                  out_pdu = pmt.init_u8vector(len(final_packet), final_packet)
                  out_msg = pmt.cons(pmt.PMT_NIL, out_pdu)
                  self.message_port_pub(pmt.intern("out"), out_msg)

              except Exception as e:
                  print(f"[AES Encrypt] Error: {e}")
    key_str: '"1234567890123456"'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    dev_args: '0'
    gain: '60'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    dev_args: '0'
    gain: '60'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '9000'
    center_freq: freq
    dev_args: '0'
    gain: '30'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '9000'
    center_freq: freq
    dev_args: '0'
    gain: '30'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:6666
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:6667
    bind: 'False'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5557
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_2, '0', blocks_throttle2_0_2, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_tagged_stream_mux_0_1, '0', blocks_repack_bits_bb_1_0_2, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_1, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_1_1, '0', channels_channel_model_0_1, '0']
- [blocks_throttle2_0_2, '0', digital_constellation_modulator_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [channels_channel_model_0_1, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_constellation_modulator_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_throttle2_0_1_1, '0']
- [digital_constellation_modulator_0_1, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_constellation_modulator_0_1, '0', qtgui_freq_sink_x_1_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_crc_append_0, out, epy_block_12, data_in]
- [digital_crc_append_0_0, out, epy_block_12_0, data_in]
- [digital_crc_append_0_0_0, out, epy_block_12, ack_in]
- [digital_crc_append_0_0_0_0, out, epy_block_12_0, ack_in]
- [digital_crc_check_0_0, fail, epy_block_1, in]
- [digital_crc_check_0_0, ok, epy_block_7_1_0_0, pdu_in]
- [digital_crc_check_0_0_0, fail, epy_block_1_0, in]
- [digital_crc_check_0_0_0, ok, epy_block_7_1_0, pdu_in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_1, header, pdu_pdu_to_tagged_stream_0_2, pdus]
- [digital_protocol_formatter_async_0_1, payload, pdu_pdu_to_tagged_stream_0_0_1, pdus]
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [epy_block_0, out, digital_crc_append_0_0_0_0, in]
- [epy_block_0_1, out, digital_crc_append_0_0_0, in]
- [epy_block_10, pdu_out, digital_crc_check_0_0_0, in]
- [epy_block_10_1, pdu_out, digital_protocol_formatter_async_0_1, in]
- [epy_block_11, out, epy_block_7_0, pdu_in]
- [epy_block_11_1, out, epy_block_13, in]
- [epy_block_11_1, out, epy_block_7, pdu_in]
- [epy_block_12, pdu_out, epy_block_2, pdu_in]
- [epy_block_12_0, pdu_out, epy_block_2_2, pdu_in]
- [epy_block_2, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_2_2, pdu_out, digital_protocol_formatter_async_0_1, in]
- [epy_block_2_2, pdu_out, epy_block_10_1, pdu_in]
- [epy_block_3_0, pdu_out, digital_crc_check_0_0, in]
- [epy_block_4, out, epy_block_9, in]
- [epy_block_4_0, out, epy_block_9_0, in]
- [epy_block_5, pdu_out, digital_crc_append_0, in]
- [epy_block_5_0, pdu_out, digital_crc_append_0_0, in]
- [epy_block_6, pdu_out, epy_block_5, rn_in]
- [epy_block_6_0, pdu_out, epy_block_5_0, rn_in]
- [epy_block_7, to_ack, epy_block_8, pdu_in]
- [epy_block_7, to_app, zeromq_push_msg_sink_0, in]
- [epy_block_7_0, to_ack, epy_block_8_0, pdu_in]
- [epy_block_7_0, to_app, zeromq_push_msg_sink_0_0, in]
- [epy_block_7_1_0, ack_out, blocks_message_debug_0_1, print]
- [epy_block_7_1_0, ack_out, epy_block_3_1, in]
- [epy_block_7_1_0, ack_out, epy_block_6_0, pdu_in]
- [epy_block_7_1_0, pdu_out, epy_block_11_1, in]
- [epy_block_7_1_0_0, ack_out, blocks_message_debug_0, print]
- [epy_block_7_1_0_0, ack_out, epy_block_3, in]
- [epy_block_7_1_0_0, ack_out, epy_block_6, pdu_in]
- [epy_block_7_1_0_0, pdu_out, epy_block_11, in]
- [epy_block_8, pdu_out, epy_block_0, in]
- [epy_block_8_0, pdu_out, epy_block_0_1, in]
- [epy_block_9, out, epy_block_5, pdu_in]
- [epy_block_9_0, out, epy_block_5_0, pdu_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_1, '0', blocks_tagged_stream_mux_0_1, '1']
- [pdu_pdu_to_tagged_stream_0_2, '0', blocks_tagged_stream_mux_0_1, '0']
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_block_3_0, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, epy_block_10, pdu_in]
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [zeromq_pull_msg_source_0, out, epy_block_4, in]
- [zeromq_pull_msg_source_0_0, out, epy_block_4_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
