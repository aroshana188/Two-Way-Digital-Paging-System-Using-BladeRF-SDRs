options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_8
    output_language: python
    title: pkt_8
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '42'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 100e3
    stop: 6e9
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '00'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.2'
  states: {state: disabled}
- name: phase_bw
  id: variable
  parameters:
    value: '0.05'
  states: {state: disabled}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {state: disabled}
- name: phase_bw
  id: variable
  parameters:
    value: 6.28/100.0
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: sample_rate_blade
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: tuning_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Tuning
    start: '-70e3'
    step: '50'
    stop: 70e3
    value: '-21e3'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_1
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {state: disabled}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {state: disabled}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {state: disabled}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {state: disabled}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: File Source PDU (Corrected for 1-Byte SN)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time
      import struct
      import os

      class file_source_pdu(gr.basic_block):
          def __init__(self, filename='message.txt', pdu_size=64, delay=0.05):
              """
              Args:
                  filename: Path to the text file.
                  pdu_size: Total size of the output PDU in bytes.
                  delay: Time delay between sending PDUs.
              """
              gr.basic_block.__init__(self,
                  name="File Source PDU",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              self.filename = filename
              self.pdu_size = pdu_size
              self.delay = delay
              
              # FIXED: Hardcoded to 1 byte because your Receiver expects data_bytes[0] to be the SN
              self.seq_len = 1 
              self.payload_size = self.pdu_size - self.seq_len

              self.stop_thread = False
              self.thread = threading.Thread(target=self.run)
              self.thread.daemon = True

          def start(self):
              self.stop_thread = False
              self.thread.start()
              return True

          def stop(self):
              self.stop_thread = True
              if self.thread.is_alive():
                  self.thread.join()
              return True

          def run(self):
              time.sleep(1)
              
              if not os.path.exists(self.filename):
                  print(f"[Error] File not found: {self.filename}")
                  return

              with open(self.filename, 'rb') as f:
                  file_content = f.read()

              data = bytearray(file_content)
              total_len = len(data)
              num_packets = (total_len + self.payload_size - 1) // self.payload_size
              
              print(f"[File Source] Sending {total_len} bytes in {num_packets} packets.")

              seq_num = 0
              
              for i in range(0, total_len, self.payload_size):
                  if self.stop_thread:
                      break

                  # 1. Slice the data
                  chunk = data[i : i + self.payload_size]
                  
                  # 2. Add Sequence Number (Header)
                  # FIXED: 'B' packs it as a single unsigned byte (0-255)
                  # We use % 256 to ensure it wraps around and doesn't crash if file is large
                  header = struct.pack('B', seq_num % 256) 
                  
                  # 3. Add Padding (if needed)
                  current_len = len(chunk) + len(header)
                  padding_len = self.pdu_size - current_len
                  
                  if padding_len > 0:
                      padding = b'\x00' * padding_len
                      chunk = chunk + padding
                  
                  # Combine
                  full_packet = header + chunk
                  
                  # 4. Create PDU
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("seq_num"), pmt.from_long(seq_num))
                  
                  # Convert to PMT vector
                  pdu_vector = pmt.init_u8vector(len(full_packet), list(full_packet))
                  pdu = pmt.cons(meta, pdu_vector)
                  
                  # 5. Send
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)
                  
                  print(f"[Sent] Seq: {seq_num % 256}, Size: {len(full_packet)}")
                  
                  seq_num += 1
                  time.sleep(self.delay)
    delay: '0.1'
    filename: '"C:/Users/PC/Desktop/Input.txt"'
    pdu_size: '64'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class crc_fail_logger(gr.basic_block):
          def __init__(self, log_file=''):
              gr.basic_block.__init__(self,
                  name="CRC Fail Logger",
                  in_sig=None,
                  out_sig=None)

              # INPUT: Connect this to the 'fail' port of the CRC Check block
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              
              self.fail_count = 0
              
              # LOGGING SETUP
              self.log_file_path = log_file
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- CRC FAILURE LOG START ---\n")
                  except: pass

          def log(self, message):
              """Helper function to Print AND Write to file"""
              print(message)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          timestamp = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{timestamp}] {message}\n")
                  except: pass

          def handle_msg(self, msg):
              try:
                  self.fail_count += 1
                  
                  # Extract the length of the bad packet just for info
                  payload = pmt.cdr(msg)
                  data_len = len(pmt.u8vector_elements(payload))
                  
                  self.log(f"[CRC FAIL] Corrupted Packet Dropped! (Size: {data_len} bytes | Total Fails: {self.fail_count})")
                  
              except Exception as e:
                  self.log(f"[CRC Log Error] {e}")
    log_file: '"C:/Users/PC/Desktop/Receiver log.txt"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Storage & ARQ Controller (With Debug Prints)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class pdu_arq_controller(gr.basic_block):
          def __init__(self, timeout_s=1.0, max_retries=5):
              gr.basic_block.__init__(self,
                  name="PDU Storage ARQ",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Message Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("request_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 2. Bind Message Handlers
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("request_in"), self.handle_request)

              # 3. State Variables
              self.buffer = []          
              self.curr_idx = 0         
              self.retries = 0          
              self.max_retries = max_retries
              self.timeout_s = timeout_s 
              
              # Timer and Thread Safety
              self.timer = None
              self.lock = threading.Lock() 

              print(f"[ARQ] Block Initialized. Timeout: {self.timeout_s}s, Max Retries: {self.max_retries}")

          def __del__(self):
              self.stop_timer()

          def stop_timer(self):
              if self.timer:
                  self.timer.cancel()
                  self.timer = None

          def start_timer(self):
              self.stop_timer() 
              # Create a new timer thread
              self.timer = threading.Timer(self.timeout_s, self.handle_timeout)
              self.timer.start()
              # Debug Print
              # print(f"[ARQ] Timer started for {self.timeout_s}s") 

          def send_packet(self, index):
              # Note: This function is usually called from inside a locked context
              if index < len(self.buffer):
                  pdu = self.buffer[index]
                  
                  # Send PDU
                  self.message_port_pub(pmt.intern("pdu_out"), pdu)
                  
                  print(f"[ARQ] SENT Packet {index} (Retry {self.retries}/{self.max_retries})")
                  
                  # Restart Timer
                  self.start_timer()
              else:
                  print(f"[ARQ] Waiting... (Index {index} not in buffer of size {len(self.buffer)})")

          def handle_timeout(self):
              """ Triggered when timer expires """
              with self.lock:
                  print(f"[ARQ] TIMEOUT reached for Packet {self.curr_idx}")

                  if self.curr_idx >= len(self.buffer):
                      print("[ARQ] Buffer exhausted, nothing to send.")
                      return

                  if self.retries < self.max_retries:
                      # Case A: Retry limit not reached -> Resend Same Packet
                      self.retries += 1
                      print(f"[ARQ] Retry limit not reached. Resending Packet {self.curr_idx}...")
                      self.send_packet(self.curr_idx)
                  else:
                      # Case B: Max retries reached -> Give Up & Move Next
                      print(f"[ARQ] MAX RETRIES ({self.max_retries}) reached for Packet {self.curr_idx}. SKIPPING.")
                      
                      self.curr_idx += 1
                      self.retries = 0 
                      
                      if self.curr_idx < len(self.buffer):
                          print(f"[ARQ] Advancing to Packet {self.curr_idx}")
                          self.send_packet(self.curr_idx)
                      else:
                          print("[ARQ] No more packets to send.")

          def handle_request(self, msg):
              """ Triggered when receiver asks for a packet """
              with self.lock:
                  try:
                      # Robust input parsing
                      if pmt.is_pdu(msg):
                          data = pmt.to_python(pmt.cdr(msg))
                          req_num = int(data[0]) 
                      elif pmt.is_integer(msg):
                          req_num = pmt.to_long(msg)
                      elif pmt.is_pair(msg): 
                          # Sometimes integers come as a pair (val . val)
                          req_num = pmt.to_long(pmt.car(msg))
                      else:
                          print(f"[ARQ] Error: Unknown request message format: {msg}")
                          return
                  except Exception as e:
                      print(f"[ARQ] Error parsing request: {e}")
                      return

                  print(f"[ARQ] REQUEST RECEIVED for Packet {req_num}")

                  # Logic: Receiver wants 'req_num'
                  # We reset retries because the link is alive (we got a request)
                  self.curr_idx = req_num
                  self.retries = 0
                  
                  # Send immediately and restart timer
                  self.send_packet(self.curr_idx)

          def handle_pdu(self, msg):
              """ Triggered when File Source provides data """
              with self.lock:
                  self.buffer.append(msg)
                  print(f"[ARQ] STORED new PDU. Buffer size: {len(self.buffer)}")
                  
                  # If this is the FIRST packet arriving, kickstart the process
                  if len(self.buffer) == 1:
                      print("[ARQ] Starting transmission with Packet 0")
                      self.curr_idx = 0
                      self.retries = 0
                      self.send_packet(0)
    max_retries: '5'
    timeout_s: '3'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Duplicator
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_duplicator(gr.basic_block):
          def __init__(self, num_duplicates=3):
              # Default value ensures GRC doesn't throw an error
              gr.basic_block.__init__(self,
                  name="PDU Duplicator",
                  in_sig=None,
                  out_sig=None)
              
              # Save parameter
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Check if the message is a valid PDU
              if pmt.is_pdu(msg):
                  # Extract metadata and data vector
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # 2. Convert PMT vector to a standard Python list of bytes
                  # The input 'vector_data' already contains [Payload + CRC]
                  input_bytes = pmt.u8vector_elements(vector_data)
                  
                  # 3. Duplicate the list N times
                  # In Python, [1, 2] * 3 becomes [1, 2, 1, 2, 1, 2]
                  new_bytes = list(input_bytes) * self.n
                  
                  # 4. Create a new PMT u8vector from the long list
                  out_vector = pmt.init_u8vector(len(new_bytes), new_bytes)
                  
                  # 5. Create the new PDU (preserving original metadata)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # 6. Publish
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: '10'
  states: {state: disabled}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Duplicator
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_duplicator(gr.basic_block):
          def __init__(self, num_duplicates=3):
              # Default value ensures GRC doesn't throw an error
              gr.basic_block.__init__(self,
                  name="PDU Duplicator",
                  in_sig=None,
                  out_sig=None)
              
              # Save parameter
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Check if the message is a valid PDU
              if pmt.is_pdu(msg):
                  # Extract metadata and data vector
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # 2. Convert PMT vector to a standard Python list of bytes
                  # The input 'vector_data' already contains [Payload + CRC]
                  input_bytes = pmt.u8vector_elements(vector_data)
                  
                  # 3. Duplicate the list N times
                  # In Python, [1, 2] * 3 becomes [1, 2, 1, 2, 1, 2]
                  new_bytes = list(input_bytes) * self.n
                  
                  # 4. Create a new PMT u8vector from the long list
                  out_vector = pmt.init_u8vector(len(new_bytes), new_bytes)
                  
                  # 5. Create the new PDU (preserving original metadata)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # 6. Publish
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: '10'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Splitter
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_splitter(gr.basic_block):
          def __init__(self, num_duplicates=10):
              # Default num_duplicates set to 10 to match your transmitter image
              gr.basic_block.__init__(self,
                  name="PDU Splitter",
                  in_sig=None,
                  out_sig=None)
              
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # Ensure we are handling a PDU
              if pmt.is_pdu(msg):
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # Convert PMT vector to Python list/tuple of bytes
                  data = pmt.u8vector_elements(vector_data)
                  total_len = len(data)
                  
                  # Validation: The total length must be divisible by N
                  if total_len == 0 or (total_len % self.n != 0):
                      # If the packet size is wrong (likely due to noise shifting the header),
                      # we cannot safely split it. Drop it.
                      return

                  # Calculate the size of one sub-packet (Payload + CRC)
                  chunk_len = total_len // self.n
                  
                  # Loop N times to slice and send each copy
                  for i in range(self.n):
                      start = i * chunk_len
                      end = start + chunk_len
                      
                      # Extract the slice
                      sub_packet = data[start:end]
                      
                      # Create new PMT vector
                      out_vector = pmt.init_u8vector(len(sub_packet), sub_packet)
                      
                      # Create new PDU (preserving original metadata)
                      out_msg = pmt.cons(meta, out_vector)
                      
                      # Send to output
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: '10'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Splitter
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_splitter(gr.basic_block):
          def __init__(self, num_duplicates=10):
              # Default num_duplicates set to 10 to match your transmitter image
              gr.basic_block.__init__(self,
                  name="PDU Splitter",
                  in_sig=None,
                  out_sig=None)
              
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # Ensure we are handling a PDU
              if pmt.is_pdu(msg):
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # Convert PMT vector to Python list/tuple of bytes
                  data = pmt.u8vector_elements(vector_data)
                  total_len = len(data)
                  
                  # Validation: The total length must be divisible by N
                  if total_len == 0 or (total_len % self.n != 0):
                      # If the packet size is wrong (likely due to noise shifting the header),
                      # we cannot safely split it. Drop it.
                      return

                  # Calculate the size of one sub-packet (Payload + CRC)
                  chunk_len = total_len // self.n
                  
                  # Loop N times to slice and send each copy
                  for i in range(self.n):
                      start = i * chunk_len
                      end = start + chunk_len
                      
                      # Extract the slice
                      sub_packet = data[start:end]
                      
                      # Create new PMT vector
                      out_vector = pmt.init_u8vector(len(sub_packet), sub_packet)
                      
                      # Create new PDU (preserving original metadata)
                      out_msg = pmt.cons(meta, out_vector)
                      
                      # Send to output
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: '10'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Sequence Number Checker & ARQ Logic (With Address Passthrough)
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class seq_num_checker(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Sequence Num Checker",
                  in_sig=None,
                  out_sig=None)

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))      # For valid data
              self.message_port_register_out(pmt.intern("request_out"))  # For ACKs (Addr + ReqNum)

              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # Internal State
              self.rn = 0  # Request Number (The Sequence Number we are waiting for)
              print("[RX Checker] Block Initialized. Waiting for Packet 0.")

          def handle_msg(self, msg):
              # 1. Validate PDU
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = pmt.u8vector_elements(data_pdu)
              
              if len(data_bytes) < 1:
                  print("[RX Checker] Warning: Received empty packet.")
                  return 

              # 2. Extract Source Address from Metadata
              # We assume the previous block (Address Filter) saved 'src_addr' in metadata
              src_addr_pmt = pmt.dict_ref(meta, pmt.intern("src_addr"), pmt.from_long(0))
              current_src_addr = pmt.to_long(src_addr_pmt)

              # 3. Get Sequence Number (First byte)
              sn_received = data_bytes[0]

              # Debug Print
              print(f"[RX Checker] INCOMING from Src {current_src_addr}: SN={sn_received} | EXPECTING: RN={self.rn}")

              # 4. Compare SN with RN
              if sn_received == self.rn:
                  # --- VALID PACKET CASE ---
                  print(f"    -> MATCH! Accepting Packet {sn_received}.")
                  
                  # A. Prepare Payload (Strip SN)
                  payload = data_bytes[1:]
                  
                  # B. Publish Payload
                  if len(payload) > 0:
                      out_vector = pmt.init_u8vector(len(payload), payload)
                      out_msg = pmt.cons(meta, out_vector)
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
                  # C. Increment Request Number
                  old_rn = self.rn
                  self.rn = (self.rn + 1) % 256
                  
                  # D. Send NEW Request Number (+ Address of who sent the data)
                  print(f"    -> UPDATING RN: {old_rn} -> {self.rn}. Sending ACK to Src {current_src_addr}")
                  self.send_request(self.rn, current_src_addr)
                  
              else:
                  # --- DUPLICATE/WRONG SN ---
                  print(f"    -> IGNORED: SN {sn_received} != RN {self.rn}. Re-sending Req {self.rn} to Src {current_src_addr}")
                  
                  # A. Re-send the CURRENT Request Number to the sender
                  self.send_request(self.rn, current_src_addr)

          def send_request(self, req_num, dest_addr):
              # Create a Pair: (Destination_Address . Request_Number)
              # The 'Destination_Address' here is the 'Source_Address' of the packet we just received
              msg_pair = pmt.cons(pmt.from_long(dest_addr), pmt.from_long(req_num))
              self.message_port_pub(pmt.intern("request_out"), msg_pair)
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU File Sink (With Append Option)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class pdu_file_sink(gr.basic_block):
          def __init__(self, filename="received_output.txt", append=False):
              gr.basic_block.__init__(self,
                  name="PDU File Sink",
                  in_sig=None,
                  out_sig=None)

              self.filename = filename
              self.append = append
              self.file_handle = None

              # Register Input Port
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # Determine Mode: 'ab' = Append Binary, 'wb' = Write Binary (Overwrite)
              mode = 'ab' if self.append else 'wb'

              try:
                  self.file_handle = open(self.filename, mode)
                  action = "Appending to" if self.append else "Overwriting"
                  print(f"PDU File Sink: {action} {self.filename}")
              except Exception as e:
                  print(f"PDU File Sink Error: Could not open file. {e}")

          def handle_msg(self, msg):
              # 1. Validate PDU
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              data_vector = pmt.cdr(msg)
              
              # 3. Convert to Bytes
              data_bytes = bytearray(pmt.u8vector_elements(data_vector))
              
              # 4. Write to Disk
              if self.file_handle:
                  self.file_handle.write(data_bytes)
                  self.file_handle.flush() # Force save immediately

          def __del__(self):
              if self.file_handle:
                  self.file_handle.close()
    append: 'False'
    filename: '"C:/Users/PC/Desktop/Output.txt"'
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU File Sink (With Append Option)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class pdu_file_sink(gr.basic_block):
          def __init__(self, filename="received_output.txt", append=False):
              gr.basic_block.__init__(self,
                  name="PDU File Sink",
                  in_sig=None,
                  out_sig=None)

              self.filename = filename
              self.append = append
              self.file_handle = None

              # Register Input Port
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # Determine Mode: 'ab' = Append Binary, 'wb' = Write Binary (Overwrite)
              mode = 'ab' if self.append else 'wb'

              try:
                  self.file_handle = open(self.filename, mode)
                  action = "Appending to" if self.append else "Overwriting"
                  print(f"PDU File Sink: {action} {self.filename}")
              except Exception as e:
                  print(f"PDU File Sink Error: Could not open file. {e}")

          def handle_msg(self, msg):
              # 1. Validate PDU
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              data_vector = pmt.cdr(msg)
              
              # 3. Convert to Bytes
              data_bytes = bytearray(pmt.u8vector_elements(data_vector))
              
              # 4. Write to Disk
              if self.file_handle:
                  self.file_handle.write(data_bytes)
                  self.file_handle.flush() # Force save immediately

          def __del__(self):
              if self.file_handle:
                  self.file_handle.close()
    append: 'False'
    filename: '"C:/Users/PC/Desktop/Output2.txt"'
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Add Addressing
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import struct

      class pdu_add_addressing(gr.basic_block):
          def __init__(self, src_addr=1, dest_addr=2):
              gr.basic_block.__init__(self,
                  name="PDU Add Addressing",
                  in_sig=None,
                  out_sig=None)

              # Parameters (0-255)
              self.src = src_addr
              self.dest = dest_addr

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              # 1. Get existing data (Seq Num + Payload)
              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = bytearray(pmt.u8vector_elements(data_pdu))

              # 2. Create Address Header (2 Bytes)
              # Format: [ Destination ] [ Source ]
              header = struct.pack('BB', self.dest, self.src)

              # 3. Prepend Header
              new_data = header + data_bytes

              # 4. Publish
              out_vector = pmt.init_u8vector(len(new_data), list(new_data))
              out_msg = pmt.cons(meta, out_vector)
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    dest_addr: '20'
    src_addr: '10'
  states: {state: disabled}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Address Filter (With Metadata Save)
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_addr_filter(gr.basic_block):
          def __init__(self, my_addr=2):
              gr.basic_block.__init__(self,
                  name="PDU Address Filter",
                  in_sig=None,
                  out_sig=None)

              # Parameter: The address of THIS receiver
              self.my_addr = my_addr

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              # Input Packet Format: [ Dest (1 Byte) ] [ Src (1 Byte) ] [ Seq Num ] [ Payload... ]
              data_pdu = pmt.cdr(msg)
              data_bytes = pmt.u8vector_elements(data_pdu)

              # Safety Check: Packet must have at least 2 bytes (Dest + Src)
              if len(data_bytes) < 2:
                  return

              # 3. Read Addresses
              dest_received = data_bytes[0]
              src_received  = data_bytes[1]

              # 4. Filter Logic
              if dest_received == self.my_addr:
                  # --- MATCH: Packet is for us ---
                  
                  # A. Strip the Address Header (First 2 bytes)
                  # Remaining data: [ Seq Num ] [ Payload... ]
                  clean_payload = data_bytes[2:]
                  
                  # B. Get existing Metadata
                  meta = pmt.car(msg)
                  
                  # C. IMPORTANT: Save Source Address to Metadata
                  # This allows the next block to know who sent this packet
                  meta = pmt.dict_add(meta, pmt.intern("src_addr"), pmt.from_long(src_received))
                  
                  # D. Create new PDU
                  out_vector = pmt.init_u8vector(len(clean_payload), clean_payload)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # E. Send to Output
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
                  # Optional Debug Print
                  # print(f"[Addr Filter] Accepted packet from Src {src_received}")
                  
              else:
                  # --- MISMATCH: Packet is for someone else ---
                  # Drop it silently or print debug info
                  # print(f"[Addr Filter] Dropped packet for Dest {dest_received} (I am {self.my_addr})")
                  pass
    my_addr: '20'
  states: {}
- name: epy_block_7_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Address Filter (With Metadata Save)
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_addr_filter(gr.basic_block):
          def __init__(self, my_addr=2):
              gr.basic_block.__init__(self,
                  name="PDU Address Filter",
                  in_sig=None,
                  out_sig=None)

              # Parameter: The address of THIS receiver
              self.my_addr = my_addr

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              # Input Packet Format: [ Dest (1 Byte) ] [ Src (1 Byte) ] [ Seq Num ] [ Payload... ]
              data_pdu = pmt.cdr(msg)
              data_bytes = pmt.u8vector_elements(data_pdu)

              # Safety Check: Packet must have at least 2 bytes (Dest + Src)
              if len(data_bytes) < 2:
                  return

              # 3. Read Addresses
              dest_received = data_bytes[0]
              src_received  = data_bytes[1]

              # 4. Filter Logic
              if dest_received == self.my_addr:
                  # --- MATCH: Packet is for us ---
                  
                  # A. Strip the Address Header (First 2 bytes)
                  # Remaining data: [ Seq Num ] [ Payload... ]
                  clean_payload = data_bytes[2:]
                  
                  # B. Get existing Metadata
                  meta = pmt.car(msg)
                  
                  # C. IMPORTANT: Save Source Address to Metadata
                  # This allows the next block to know who sent this packet
                  meta = pmt.dict_add(meta, pmt.intern("src_addr"), pmt.from_long(src_received))
                  
                  # D. Create new PDU
                  out_vector = pmt.init_u8vector(len(clean_payload), clean_payload)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # E. Send to Output
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
                  # Optional Debug Print
                  # print(f"[Addr Filter] Accepted packet from Src {src_received}")
                  
              else:
                  # --- MISMATCH: Packet is for someone else ---
                  # Drop it silently or print debug info
                  # print(f"[Addr Filter] Dropped packet for Dest {dest_received} (I am {self.my_addr})")
                  pass
    my_addr: '10'
  states: {state: disabled}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Generator (With Dummy Pattern)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import time

      class ack_generator(gr.basic_block):
          def __init__(self, my_addr=2, payload_len=100, ack_interval=0.1):
              gr.basic_block.__init__(self,
                  name="ACK Generator",
                  in_sig=None,
                  out_sig=None)

              self.my_src = my_addr
              self.p_len = payload_len
              self.interval = ack_interval

              # State for Throttling
              self.last_dest = -1
              self.last_rn = -1
              self.last_time = 0.0

              # Register Ports
              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pair(msg):
                  return

              target_dest = pmt.to_long(pmt.car(msg))
              req_num     = pmt.to_long(pmt.cdr(msg))
              
              now = time.time()
              should_send = False

              # 2. Throttling Logic
              if (target_dest == self.last_dest) and (req_num == self.last_rn):
                  if (now - self.last_time) >= self.interval:
                      should_send = True
              else:
                  should_send = True

              # 3. Construct and Send
              if should_send:
                  self.last_dest = target_dest
                  self.last_rn = req_num
                  self.last_time = now
                  
                  # Header: [ Dest ] [ Src ] [ RN ]
                  header = struct.pack('BBB', target_dest, self.my_src, req_num)

                  # --- NEW PAYLOAD GENERATION ---
                  # Create a pattern like 0x55 (01010101) which is excellent for sync
                  # Alternatively, you could use text like b'ACK_' * N
                  
                  # Method A: Binary Pattern (01010101...) - BEST FOR SYNC
                  dummy_byte = b'\x55' 
                  payload = dummy_byte * self.p_len
                  
                  # Method B: Text Pattern (Readable in Hex Editor) - Optional
                  # pattern = b'ACK_dummy_data_'
                  # repeat_count = (self.p_len // len(pattern)) + 1
                  # payload = (pattern * repeat_count)[:self.p_len]

                  full_data = header + payload

                  # Create PDU
                  meta = pmt.make_dict()
                  out_vector = pmt.init_u8vector(len(full_data), list(full_data))
                  out_msg = pmt.cons(meta, out_vector)

                  # Publish
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    ack_interval: '0.5'
    my_addr: '20'
    payload_len: '1024'
  states: {}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Extractor (PDU to Request Number)
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class ack_extractor(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="ACK Extractor",
                  in_sig=None,
                  out_sig=None)

              # Inputs and Outputs
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("request_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Get Data
              # The PDU Address Filter has already stripped the Dest and Src bytes.
              # So the data we see here is: [ RN ] [ Padding... ]
              data_pdu = pmt.cdr(msg)
              data_bytes = pmt.u8vector_elements(data_pdu)

              # Safety Check
              if len(data_bytes) < 1:
                  return

              # 3. Extract Request Number (First byte)
              rn = data_bytes[0]

              # 4. Create PMT Integer Message
              # This is exactly what the PDU Storage 'request_in' port expects
              msg_out = pmt.from_long(rn)

              # 5. Publish
              self.message_port_pub(pmt.intern("request_out"), msg_out)
              
              # Debug Print
              print(f"[TX Side] Received ACK for Packet {rn}. Updating Storage.")
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"after liner eq"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    name: after symbol sync
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_1_0
  id: qtgui_const_sink_x
  parameters:
    name: '"after costas loo"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 433.92e6
    fftsize: '1024'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    dev_args: '0'
    gain: '60'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    dev_args: '0'
    gain: '60'
    samp_rate: sample_rate_blade
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '9000'
    center_freq: freq
    dev_args: '0'
    gain: '30'
    samp_rate: sample_rate_blade
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_1, '0', blocks_throttle2_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', blocks_repack_bits_bb_1_0_1, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0_1, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_1_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0_1_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_crc_append_0, out, epy_block_2, pdu_in]
- [digital_crc_append_0_0, out, digital_protocol_formatter_async_0_0, in]
- [digital_crc_append_0_0, out, epy_block_2_0, pdu_in]
- [digital_crc_check_0, fail, epy_block_0_0, pdu_in]
- [digital_crc_check_0, fail, epy_block_5_0, pdu_in]
- [digital_crc_check_0, ok, epy_block_7, pdu_in]
- [digital_crc_check_0_0, ok, epy_block_7_0, pdu_in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_1, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [epy_block_0, pdu_out, epy_block_1, pdu_in]
- [epy_block_1, pdu_out, epy_block_6, pdu_in]
- [epy_block_2, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_2_0, pdu_out, digital_protocol_formatter_async_0_0, in]
- [epy_block_3, pdu_out, digital_crc_check_0, in]
- [epy_block_3_0, pdu_out, digital_crc_check_0_0, in]
- [epy_block_4, pdu_out, epy_block_5, pdu_in]
- [epy_block_4, request_out, blocks_message_debug_0_0, print]
- [epy_block_4, request_out, epy_block_8, msg_in]
- [epy_block_6, pdu_out, digital_crc_append_0, in]
- [epy_block_7, pdu_out, epy_block_4, pdu_in]
- [epy_block_7_0, pdu_out, epy_block_9, pdu_in]
- [epy_block_8, pdu_out, digital_crc_append_0_0, in]
- [epy_block_9, request_out, blocks_message_debug_0, print]
- [epy_block_9, request_out, epy_block_1, request_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_3, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_block_3_0, pdu_in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
