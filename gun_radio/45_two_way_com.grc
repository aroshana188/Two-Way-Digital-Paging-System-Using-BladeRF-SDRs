options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_8
    output_language: python
    title: pkt_8
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '42'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: extra_bytes
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 100e3
    stop: 6e9
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '00'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.2'
  states: {state: disabled}
- name: num_duplicates
  id: variable
  parameters:
    value: '8'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.05'
  states: {state: disabled}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {state: disabled}
- name: phase_bw
  id: variable
  parameters:
    value: 6.28/100.0
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: sample_rate_blade
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: tuning_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Tuning
    start: '-70e3'
    step: '50'
    stop: 70e3
    value: '-21e3'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_2
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: channels_channel_model_0_1
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_1
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_1
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: File Source PDU (Corrected for 1-Byte SN)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time
      import struct
      import os

      class file_source_pdu(gr.basic_block):
          def __init__(self, filename='message.txt', pdu_size=64, delay=0.05):
              """
              Args:
                  filename: Path to the text file.
                  pdu_size: Total size of the output PDU in bytes.
                  delay: Time delay between sending PDUs.
              """
              gr.basic_block.__init__(self,
                  name="File Source PDU",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              self.filename = filename
              self.pdu_size = pdu_size
              self.delay = delay
              
              # FIXED: Hardcoded to 1 byte because your Receiver expects data_bytes[0] to be the SN
              self.seq_len = 1 
              self.payload_size = self.pdu_size - self.seq_len

              self.stop_thread = False
              self.thread = threading.Thread(target=self.run)
              self.thread.daemon = True

          def start(self):
              self.stop_thread = False
              self.thread.start()
              return True

          def stop(self):
              self.stop_thread = True
              if self.thread.is_alive():
                  self.thread.join()
              return True

          def run(self):
              time.sleep(1)
              
              if not os.path.exists(self.filename):
                  print(f"[Error] File not found: {self.filename}")
                  return

              with open(self.filename, 'rb') as f:
                  file_content = f.read()

              data = bytearray(file_content)
              total_len = len(data)
              num_packets = (total_len + self.payload_size - 1) // self.payload_size
              
              print(f"[File Source] Sending {total_len} bytes in {num_packets} packets.")

              seq_num = 0
              
              for i in range(0, total_len, self.payload_size):
                  if self.stop_thread:
                      break

                  # 1. Slice the data
                  chunk = data[i : i + self.payload_size]
                  
                  # 2. Add Sequence Number (Header)
                  # FIXED: 'B' packs it as a single unsigned byte (0-255)
                  # We use % 256 to ensure it wraps around and doesn't crash if file is large
                  header = struct.pack('B', seq_num % 256) 
                  
                  # 3. Add Padding (if needed)
                  current_len = len(chunk) + len(header)
                  padding_len = self.pdu_size - current_len
                  
                  if padding_len > 0:
                      padding = b'\x00' * padding_len
                      chunk = chunk + padding
                  
                  # Combine
                  full_packet = header + chunk
                  
                  # 4. Create PDU
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("seq_num"), pmt.from_long(seq_num))
                  
                  # Convert to PMT vector
                  pdu_vector = pmt.init_u8vector(len(full_packet), list(full_packet))
                  pdu = pmt.cons(meta, pdu_vector)
                  
                  # 5. Send
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)
                  
                  print(f"[Sent] Seq: {seq_num % 256}, Size: {len(full_packet)}")
                  
                  seq_num += 1
                  time.sleep(self.delay)
    delay: '0.1'
    filename: '"C:/Users/PC/Desktop/TX_1.txt"'
    pdu_size: '64'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: File Source PDU (Corrected for 1-Byte SN)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time
      import struct
      import os

      class file_source_pdu(gr.basic_block):
          def __init__(self, filename='message.txt', pdu_size=64, delay=0.05):
              """
              Args:
                  filename: Path to the text file.
                  pdu_size: Total size of the output PDU in bytes.
                  delay: Time delay between sending PDUs.
              """
              gr.basic_block.__init__(self,
                  name="File Source PDU",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('pdu_out'))

              self.filename = filename
              self.pdu_size = pdu_size
              self.delay = delay
              
              # FIXED: Hardcoded to 1 byte because your Receiver expects data_bytes[0] to be the SN
              self.seq_len = 1 
              self.payload_size = self.pdu_size - self.seq_len

              self.stop_thread = False
              self.thread = threading.Thread(target=self.run)
              self.thread.daemon = True

          def start(self):
              self.stop_thread = False
              self.thread.start()
              return True

          def stop(self):
              self.stop_thread = True
              if self.thread.is_alive():
                  self.thread.join()
              return True

          def run(self):
              time.sleep(1)
              
              if not os.path.exists(self.filename):
                  print(f"[Error] File not found: {self.filename}")
                  return

              with open(self.filename, 'rb') as f:
                  file_content = f.read()

              data = bytearray(file_content)
              total_len = len(data)
              num_packets = (total_len + self.payload_size - 1) // self.payload_size
              
              print(f"[File Source] Sending {total_len} bytes in {num_packets} packets.")

              seq_num = 0
              
              for i in range(0, total_len, self.payload_size):
                  if self.stop_thread:
                      break

                  # 1. Slice the data
                  chunk = data[i : i + self.payload_size]
                  
                  # 2. Add Sequence Number (Header)
                  # FIXED: 'B' packs it as a single unsigned byte (0-255)
                  # We use % 256 to ensure it wraps around and doesn't crash if file is large
                  header = struct.pack('B', seq_num % 256) 
                  
                  # 3. Add Padding (if needed)
                  current_len = len(chunk) + len(header)
                  padding_len = self.pdu_size - current_len
                  
                  if padding_len > 0:
                      padding = b'\x00' * padding_len
                      chunk = chunk + padding
                  
                  # Combine
                  full_packet = header + chunk
                  
                  # 4. Create PDU
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("seq_num"), pmt.from_long(seq_num))
                  
                  # Convert to PMT vector
                  pdu_vector = pmt.init_u8vector(len(full_packet), list(full_packet))
                  pdu = pmt.cons(meta, pdu_vector)
                  
                  # 5. Send
                  self.message_port_pub(pmt.intern('pdu_out'), pdu)
                  
                  print(f"[Sent] Seq: {seq_num % 256}, Size: {len(full_packet)}")
                  
                  seq_num += 1
                  time.sleep(self.delay)
    delay: '0.1'
    filename: '"C:/Users/PC/Desktop/TX_2.txt"'
    pdu_size: '64'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Storage & ARQ Controller (With Debug Prints)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class pdu_arq_controller(gr.basic_block):
          def __init__(self, timeout_s=1.0, max_retries=5):
              gr.basic_block.__init__(self,
                  name="PDU Storage ARQ",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Message Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("request_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 2. Bind Message Handlers
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("request_in"), self.handle_request)

              # 3. State Variables
              self.buffer = []          
              self.curr_idx = 0         
              self.retries = 0          
              self.max_retries = max_retries
              self.timeout_s = timeout_s 
              
              # Timer and Thread Safety
              self.timer = None
              self.lock = threading.Lock() 

              print(f"[ARQ] Block Initialized. Timeout: {self.timeout_s}s, Max Retries: {self.max_retries}")

          def __del__(self):
              self.stop_timer()

          def stop_timer(self):
              if self.timer:
                  self.timer.cancel()
                  self.timer = None

          def start_timer(self):
              self.stop_timer() 
              # Create a new timer thread
              self.timer = threading.Timer(self.timeout_s, self.handle_timeout)
              self.timer.start()
              # Debug Print
              # print(f"[ARQ] Timer started for {self.timeout_s}s") 

          def send_packet(self, index):
              # Note: This function is usually called from inside a locked context
              if index < len(self.buffer):
                  pdu = self.buffer[index]
                  
                  # Send PDU
                  self.message_port_pub(pmt.intern("pdu_out"), pdu)
                  
                  print(f"[ARQ] SENT Packet {index} (Retry {self.retries}/{self.max_retries})")
                  
                  # Restart Timer
                  self.start_timer()
              else:
                  print(f"[ARQ] Waiting... (Index {index} not in buffer of size {len(self.buffer)})")

          def handle_timeout(self):
              """ Triggered when timer expires """
              with self.lock:
                  print(f"[ARQ] TIMEOUT reached for Packet {self.curr_idx}")

                  if self.curr_idx >= len(self.buffer):
                      print("[ARQ] Buffer exhausted, nothing to send.")
                      return

                  if self.retries < self.max_retries:
                      # Case A: Retry limit not reached -> Resend Same Packet
                      self.retries += 1
                      print(f"[ARQ] Retry limit not reached. Resending Packet {self.curr_idx}...")
                      self.send_packet(self.curr_idx)
                  else:
                      # Case B: Max retries reached -> Give Up & Move Next
                      print(f"[ARQ] MAX RETRIES ({self.max_retries}) reached for Packet {self.curr_idx}. SKIPPING.")
                      
                      self.curr_idx += 1
                      self.retries = 0 
                      
                      if self.curr_idx < len(self.buffer):
                          print(f"[ARQ] Advancing to Packet {self.curr_idx}")
                          self.send_packet(self.curr_idx)
                      else:
                          print("[ARQ] No more packets to send.")

          def handle_request(self, msg):
              """ Triggered when receiver asks for a packet """
              with self.lock:
                  try:
                      # Robust input parsing
                      if pmt.is_pdu(msg):
                          data = pmt.to_python(pmt.cdr(msg))
                          req_num = int(data[0]) 
                      elif pmt.is_integer(msg):
                          req_num = pmt.to_long(msg)
                      elif pmt.is_pair(msg): 
                          # Sometimes integers come as a pair (val . val)
                          req_num = pmt.to_long(pmt.car(msg))
                      else:
                          print(f"[ARQ] Error: Unknown request message format: {msg}")
                          return
                  except Exception as e:
                      print(f"[ARQ] Error parsing request: {e}")
                      return

                  print(f"[ARQ] REQUEST RECEIVED for Packet {req_num}")

                  # Logic: Receiver wants 'req_num'
                  # We reset retries because the link is alive (we got a request)
                  self.curr_idx = req_num
                  self.retries = 0
                  
                  # Send immediately and restart timer
                  self.send_packet(self.curr_idx)

          def handle_pdu(self, msg):
              """ Triggered when File Source provides data """
              with self.lock:
                  self.buffer.append(msg)
                  print(f"[ARQ] STORED new PDU. Buffer size: {len(self.buffer)}")
                  
                  # If this is the FIRST packet arriving, kickstart the process
                  if len(self.buffer) == 1:
                      print("[ARQ] Starting transmission with Packet 0")
                      self.curr_idx = 0
                      self.retries = 0
                      self.send_packet(0)
    max_retries: '10'
    timeout_s: '1'
  states: {}
- name: epy_block_10
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Prepend Dummy
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_prepend_dummy(gr.basic_block):
          def __init__(self, dummy_bytes=20):
              """
              Args:
                  dummy_bytes: Number of '0x55' bytes to add to the front.
              """
              gr.basic_block.__init__(self,
                  name="PDU Prepend Dummy",
                  in_sig=None,
                  out_sig=None)

              self.d_len = dummy_bytes

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              original_data = list(pmt.u8vector_elements(data_pdu))
              
              # 3. Create Dummy Data
              # We use 0x55 (Binary: 01010101) because it creates excellent 
              # bit transitions for synchronization.
              dummy_pattern = [0x55] * self.d_len
              
              # 4. Prepend (Dummy + Original)
              new_data = dummy_pattern + original_data
              
              # 5. Pack and Publish
              out_vector = pmt.init_u8vector(len(new_data), new_data)
              out_msg = pmt.cons(meta, out_vector)
              
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    dummy_bytes: extra_bytes
  states: {state: disabled}
- name: epy_block_10_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Prepend Dummy
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_prepend_dummy(gr.basic_block):
          def __init__(self, dummy_bytes=20):
              """
              Args:
                  dummy_bytes: Number of '0x55' bytes to add to the front.
              """
              gr.basic_block.__init__(self,
                  name="PDU Prepend Dummy",
                  in_sig=None,
                  out_sig=None)

              self.d_len = dummy_bytes

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              original_data = list(pmt.u8vector_elements(data_pdu))
              
              # 3. Create Dummy Data
              # We use 0x55 (Binary: 01010101) because it creates excellent 
              # bit transitions for synchronization.
              dummy_pattern = [0x55] * self.d_len
              
              # 4. Prepend (Dummy + Original)
              new_data = dummy_pattern + original_data
              
              # 5. Pack and Publish
              out_vector = pmt.init_u8vector(len(new_data), new_data)
              out_msg = pmt.cons(meta, out_vector)
              
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    dummy_bytes: extra_bytes
  states: {state: disabled}
- name: epy_block_11_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Head Stripper
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_head_stripper(gr.basic_block):
          def __init__(self, strip_bytes=20):
              """
              Args:
                  strip_bytes: Number of bytes to remove from the beginning of the packet.
              """
              gr.basic_block.__init__(self,
                  name="PDU Head Stripper",
                  in_sig=None,
                  out_sig=None)

              self.n_strip = strip_bytes

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = pmt.u8vector_elements(data_pdu)
              
              # 3. Safety Check
              # If packet is smaller than what we want to strip, drop it.
              if len(data_bytes) <= self.n_strip:
                  return

              # 4. Strip the Head
              # We take everything starting from index 'n_strip' to the end
              clean_data = data_bytes[self.n_strip:]
              
              # 5. Pack and Publish
              out_vector = pmt.init_u8vector(len(clean_data), clean_data)
              out_msg = pmt.cons(meta, out_vector)
              
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    strip_bytes: '3200'
  states: {state: disabled}
- name: epy_block_11_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Head Stripper
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_head_stripper(gr.basic_block):
          def __init__(self, strip_bytes=20):
              """
              Args:
                  strip_bytes: Number of bytes to remove from the beginning of the packet.
              """
              gr.basic_block.__init__(self,
                  name="PDU Head Stripper",
                  in_sig=None,
                  out_sig=None)

              self.n_strip = strip_bytes

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = pmt.u8vector_elements(data_pdu)
              
              # 3. Safety Check
              # If packet is smaller than what we want to strip, drop it.
              if len(data_bytes) <= self.n_strip:
                  return

              # 4. Strip the Head
              # We take everything starting from index 'n_strip' to the end
              clean_data = data_bytes[self.n_strip:]
              
              # 5. Pack and Publish
              out_vector = pmt.init_u8vector(len(clean_data), clean_data)
              out_msg = pmt.cons(meta, out_vector)
              
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    strip_bytes: '3200'
  states: {state: disabled}
- name: epy_block_12
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Priority PDU Mux
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading

      class priority_mux(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Priority PDU Mux",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Inputs
              self.message_port_register_in(pmt.intern("data_in"))
              self.message_port_register_in(pmt.intern("ack_in"))
              
              # 2. Register Output
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 3. Bind Handlers
              self.set_msg_handler(pmt.intern("data_in"), self.handle_data)
              self.set_msg_handler(pmt.intern("ack_in"), self.handle_ack)
              
              # Thread lock to prevent race conditions when two packets arrive at once
              self.lock = threading.Lock()

          def handle_ack(self, msg):
              """
              Handler for ACKs (High Priority).
              These usually come from the ACK Generator.
              """
              with self.lock:
                  # Pass through immediately
                  self.message_port_pub(pmt.intern("pdu_out"), msg)
                  # Optional: print("[Mux] Forwarding ACK")

          def handle_data(self, msg):
              """
              Handler for Data Packets (Normal Priority).
              These usually come from PDU Storage -> Add Addressing.
              """
              with self.lock:
                  # Pass through immediately
                  self.message_port_pub(pmt.intern("pdu_out"), msg)
                  # Optional: print("[Mux] Forwarding Data")
  states: {}
- name: epy_block_12_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Priority PDU Mux
      """
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading

      class priority_mux(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Priority PDU Mux",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Inputs
              self.message_port_register_in(pmt.intern("data_in"))
              self.message_port_register_in(pmt.intern("ack_in"))
              
              # 2. Register Output
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 3. Bind Handlers
              self.set_msg_handler(pmt.intern("data_in"), self.handle_data)
              self.set_msg_handler(pmt.intern("ack_in"), self.handle_ack)
              
              # Thread lock to prevent race conditions when two packets arrive at once
              self.lock = threading.Lock()

          def handle_ack(self, msg):
              """
              Handler for ACKs (High Priority).
              These usually come from the ACK Generator.
              """
              with self.lock:
                  # Pass through immediately
                  self.message_port_pub(pmt.intern("pdu_out"), msg)
                  # Optional: print("[Mux] Forwarding ACK")

          def handle_data(self, msg):
              """
              Handler for Data Packets (Normal Priority).
              These usually come from PDU Storage -> Add Addressing.
              """
              with self.lock:
                  # Pass through immediately
                  self.message_port_pub(pmt.intern("pdu_out"), msg)
                  # Optional: print("[Mux] Forwarding Data")
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Storage & ARQ Controller (With Debug Prints)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import time

      class pdu_arq_controller(gr.basic_block):
          def __init__(self, timeout_s=1.0, max_retries=5):
              gr.basic_block.__init__(self,
                  name="PDU Storage ARQ",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Message Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("request_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 2. Bind Message Handlers
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("request_in"), self.handle_request)

              # 3. State Variables
              self.buffer = []          
              self.curr_idx = 0         
              self.retries = 0          
              self.max_retries = max_retries
              self.timeout_s = timeout_s 
              
              # Timer and Thread Safety
              self.timer = None
              self.lock = threading.Lock() 

              print(f"[ARQ] Block Initialized. Timeout: {self.timeout_s}s, Max Retries: {self.max_retries}")

          def __del__(self):
              self.stop_timer()

          def stop_timer(self):
              if self.timer:
                  self.timer.cancel()
                  self.timer = None

          def start_timer(self):
              self.stop_timer() 
              # Create a new timer thread
              self.timer = threading.Timer(self.timeout_s, self.handle_timeout)
              self.timer.start()
              # Debug Print
              # print(f"[ARQ] Timer started for {self.timeout_s}s") 

          def send_packet(self, index):
              # Note: This function is usually called from inside a locked context
              if index < len(self.buffer):
                  pdu = self.buffer[index]
                  
                  # Send PDU
                  self.message_port_pub(pmt.intern("pdu_out"), pdu)
                  
                  print(f"[ARQ] SENT Packet {index} (Retry {self.retries}/{self.max_retries})")
                  
                  # Restart Timer
                  self.start_timer()
              else:
                  print(f"[ARQ] Waiting... (Index {index} not in buffer of size {len(self.buffer)})")

          def handle_timeout(self):
              """ Triggered when timer expires """
              with self.lock:
                  print(f"[ARQ] TIMEOUT reached for Packet {self.curr_idx}")

                  if self.curr_idx >= len(self.buffer):
                      print("[ARQ] Buffer exhausted, nothing to send.")
                      return

                  if self.retries < self.max_retries:
                      # Case A: Retry limit not reached -> Resend Same Packet
                      self.retries += 1
                      print(f"[ARQ] Retry limit not reached. Resending Packet {self.curr_idx}...")
                      self.send_packet(self.curr_idx)
                  else:
                      # Case B: Max retries reached -> Give Up & Move Next
                      print(f"[ARQ] MAX RETRIES ({self.max_retries}) reached for Packet {self.curr_idx}. SKIPPING.")
                      
                      self.curr_idx += 1
                      self.retries = 0 
                      
                      if self.curr_idx < len(self.buffer):
                          print(f"[ARQ] Advancing to Packet {self.curr_idx}")
                          self.send_packet(self.curr_idx)
                      else:
                          print("[ARQ] No more packets to send.")

          def handle_request(self, msg):
              """ Triggered when receiver asks for a packet """
              with self.lock:
                  try:
                      # Robust input parsing
                      if pmt.is_pdu(msg):
                          data = pmt.to_python(pmt.cdr(msg))
                          req_num = int(data[0]) 
                      elif pmt.is_integer(msg):
                          req_num = pmt.to_long(msg)
                      elif pmt.is_pair(msg): 
                          # Sometimes integers come as a pair (val . val)
                          req_num = pmt.to_long(pmt.car(msg))
                      else:
                          print(f"[ARQ] Error: Unknown request message format: {msg}")
                          return
                  except Exception as e:
                      print(f"[ARQ] Error parsing request: {e}")
                      return

                  print(f"[ARQ] REQUEST RECEIVED for Packet {req_num}")

                  # Logic: Receiver wants 'req_num'
                  # We reset retries because the link is alive (we got a request)
                  self.curr_idx = req_num
                  self.retries = 0
                  
                  # Send immediately and restart timer
                  self.send_packet(self.curr_idx)

          def handle_pdu(self, msg):
              """ Triggered when File Source provides data """
              with self.lock:
                  self.buffer.append(msg)
                  print(f"[ARQ] STORED new PDU. Buffer size: {len(self.buffer)}")
                  
                  # If this is the FIRST packet arriving, kickstart the process
                  if len(self.buffer) == 1:
                      print("[ARQ] Starting transmission with Packet 0")
                      self.curr_idx = 0
                      self.retries = 0
                      self.send_packet(0)
    max_retries: '10'
    timeout_s: '1'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Duplicator
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_duplicator(gr.basic_block):
          def __init__(self, num_duplicates=3):
              # Default value ensures GRC doesn't throw an error
              gr.basic_block.__init__(self,
                  name="PDU Duplicator",
                  in_sig=None,
                  out_sig=None)
              
              # Save parameter
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Check if the message is a valid PDU
              if pmt.is_pdu(msg):
                  # Extract metadata and data vector
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # 2. Convert PMT vector to a standard Python list of bytes
                  # The input 'vector_data' already contains [Payload + CRC]
                  input_bytes = pmt.u8vector_elements(vector_data)
                  
                  # 3. Duplicate the list N times
                  # In Python, [1, 2] * 3 becomes [1, 2, 1, 2, 1, 2]
                  new_bytes = list(input_bytes) * self.n
                  
                  # 4. Create a new PMT u8vector from the long list
                  out_vector = pmt.init_u8vector(len(new_bytes), new_bytes)
                  
                  # 5. Create the new PDU (preserving original metadata)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # 6. Publish
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: num_duplicates
  states: {state: disabled}
- name: epy_block_2_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: AES Encrypt (Preserve SN)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import pad

      class aes_encrypt_pdu(gr.basic_block):
          def __init__(self, key_str="1234567890123456"):
              """
              Args:
                  key_str: 16-byte encryption key (String)
              """
              gr.basic_block.__init__(self,
                  name="AES Encrypt PDU",
                  in_sig=None,
                  out_sig=None)

              # Ensure key is 16 bytes (AES-128)
              self.key = key_str.encode('utf-8')[:16].ljust(16, b'\0')
              # Fixed IV for simplicity (In production, use random IV and send it)
              self.iv = b'\x00' * 16

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = bytearray(pmt.u8vector_elements(data_pdu))

              if len(data_bytes) < 1:
                  return

              # 1. Separate SN and Payload
              sn_byte = data_bytes[0:1]       # First byte is Sequence Number
              payload = data_bytes[1:]        # Rest is Data

              # 2. Encrypt Payload
              # We must create a new Cipher for every packet to reset state
              cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
              
              try:
                  # Pad payload to be a multiple of 16 bytes
                  encrypted_payload = cipher.encrypt(pad(payload, AES.block_size))
                  
                  # 3. Reassemble: [SN] [Encrypted Payload]
                  new_data = sn_byte + encrypted_payload

                  # 4. Publish
                  out_vector = pmt.init_u8vector(len(new_data), list(new_data))
                  out_msg = pmt.cons(meta, out_vector)
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
              except Exception as e:
                  print(f"[AES Encrypt] Error: {e}")
    key_str: '''1234567890123456'''
  states: {}
- name: epy_block_2_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: AES Encrypt (Preserve SN)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import pad

      class aes_encrypt_pdu(gr.basic_block):
          def __init__(self, key_str="1234567890123456"):
              """
              Args:
                  key_str: 16-byte encryption key (String)
              """
              gr.basic_block.__init__(self,
                  name="AES Encrypt PDU",
                  in_sig=None,
                  out_sig=None)

              # Ensure key is 16 bytes (AES-128)
              self.key = key_str.encode('utf-8')[:16].ljust(16, b'\0')
              # Fixed IV for simplicity (In production, use random IV and send it)
              self.iv = b'\x00' * 16

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = bytearray(pmt.u8vector_elements(data_pdu))

              if len(data_bytes) < 1:
                  return

              # 1. Separate SN and Payload
              sn_byte = data_bytes[0:1]       # First byte is Sequence Number
              payload = data_bytes[1:]        # Rest is Data

              # 2. Encrypt Payload
              # We must create a new Cipher for every packet to reset state
              cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
              
              try:
                  # Pad payload to be a multiple of 16 bytes
                  encrypted_payload = cipher.encrypt(pad(payload, AES.block_size))
                  
                  # 3. Reassemble: [SN] [Encrypted Payload]
                  new_data = sn_byte + encrypted_payload

                  # 4. Publish
                  out_vector = pmt.init_u8vector(len(new_data), list(new_data))
                  out_msg = pmt.cons(meta, out_vector)
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
              except Exception as e:
                  print(f"[AES Encrypt] Error: {e}")
    key_str: '''1234567890123456'''
  states: {}
- name: epy_block_2_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Duplicator
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_duplicator(gr.basic_block):
          def __init__(self, num_duplicates=3):
              # Default value ensures GRC doesn't throw an error
              gr.basic_block.__init__(self,
                  name="PDU Duplicator",
                  in_sig=None,
                  out_sig=None)
              
              # Save parameter
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Check if the message is a valid PDU
              if pmt.is_pdu(msg):
                  # Extract metadata and data vector
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # 2. Convert PMT vector to a standard Python list of bytes
                  # The input 'vector_data' already contains [Payload + CRC]
                  input_bytes = pmt.u8vector_elements(vector_data)
                  
                  # 3. Duplicate the list N times
                  # In Python, [1, 2] * 3 becomes [1, 2, 1, 2, 1, 2]
                  new_bytes = list(input_bytes) * self.n
                  
                  # 4. Create a new PMT u8vector from the long list
                  out_vector = pmt.init_u8vector(len(new_bytes), new_bytes)
                  
                  # 5. Create the new PDU (preserving original metadata)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # 6. Publish
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: num_duplicates
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Splitter
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_splitter(gr.basic_block):
          def __init__(self, num_duplicates=10):
              # Default num_duplicates set to 10 to match your transmitter image
              gr.basic_block.__init__(self,
                  name="PDU Splitter",
                  in_sig=None,
                  out_sig=None)
              
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # Ensure we are handling a PDU
              if pmt.is_pdu(msg):
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # Convert PMT vector to Python list/tuple of bytes
                  data = pmt.u8vector_elements(vector_data)
                  total_len = len(data)
                  
                  # Validation: The total length must be divisible by N
                  if total_len == 0 or (total_len % self.n != 0):
                      # If the packet size is wrong (likely due to noise shifting the header),
                      # we cannot safely split it. Drop it.
                      return

                  # Calculate the size of one sub-packet (Payload + CRC)
                  chunk_len = total_len // self.n
                  
                  # Loop N times to slice and send each copy
                  for i in range(self.n):
                      start = i * chunk_len
                      end = start + chunk_len
                      
                      # Extract the slice
                      sub_packet = data[start:end]
                      
                      # Create new PMT vector
                      out_vector = pmt.init_u8vector(len(sub_packet), sub_packet)
                      
                      # Create new PDU (preserving original metadata)
                      out_msg = pmt.cons(meta, out_vector)
                      
                      # Send to output
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: '8'
  states: {state: disabled}
- name: epy_block_3_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Splitter
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_splitter(gr.basic_block):
          def __init__(self, num_duplicates=10):
              # Default num_duplicates set to 10 to match your transmitter image
              gr.basic_block.__init__(self,
                  name="PDU Splitter",
                  in_sig=None,
                  out_sig=None)
              
              self.n = num_duplicates

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Bind Handler
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # Ensure we are handling a PDU
              if pmt.is_pdu(msg):
                  meta = pmt.car(msg)
                  vector_data = pmt.cdr(msg)
                  
                  # Convert PMT vector to Python list/tuple of bytes
                  data = pmt.u8vector_elements(vector_data)
                  total_len = len(data)
                  
                  # Validation: The total length must be divisible by N
                  if total_len == 0 or (total_len % self.n != 0):
                      # If the packet size is wrong (likely due to noise shifting the header),
                      # we cannot safely split it. Drop it.
                      return

                  # Calculate the size of one sub-packet (Payload + CRC)
                  chunk_len = total_len // self.n
                  
                  # Loop N times to slice and send each copy
                  for i in range(self.n):
                      start = i * chunk_len
                      end = start + chunk_len
                      
                      # Extract the slice
                      sub_packet = data[start:end]
                      
                      # Create new PMT vector
                      out_vector = pmt.init_u8vector(len(sub_packet), sub_packet)
                      
                      # Create new PDU (preserving original metadata)
                      out_msg = pmt.cons(meta, out_vector)
                      
                      # Send to output
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    num_duplicates: '8'
  states: {state: disabled}
- name: epy_block_3_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: AES Decrypt
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import unpad

      class aes_decrypt_pdu(gr.basic_block):
          def __init__(self, key_str="1234567890123456"):
              """
              Args:
                  key_str: Must match the Transmitter's key!
              """
              gr.basic_block.__init__(self,
                  name="AES Decrypt PDU",
                  in_sig=None,
                  out_sig=None)

              self.key = key_str.encode('utf-8')[:16].ljust(16, b'\0')
              self.iv = b'\x00' * 16

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              encrypted_bytes = bytes(pmt.u8vector_elements(data_pdu))
              
              if len(encrypted_bytes) == 0:
                  return

              # 1. Decrypt
              cipher = AES.new(self.key, AES.MODE_CBC, self.iv)

              try:
                  # 2. Decrypt and Unpad
                  decrypted_payload = unpad(cipher.decrypt(encrypted_bytes), AES.block_size)
                  
                  # 3. Publish clean data
                  out_vector = pmt.init_u8vector(len(decrypted_payload), list(decrypted_payload))
                  out_msg = pmt.cons(meta, out_vector)
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
              except ValueError:
                  # This happens if decryption fails (e.g. padding error due to corruption)
                  print("[AES Decrypt] Error: Padding incorrect (Packet corrupted?)")
              except Exception as e:
                  print(f"[AES Decrypt] Error: {e}")
    key_str: '''1234567890123456'''
  states: {}
- name: epy_block_3_1_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: AES Decrypt
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import unpad

      class aes_decrypt_pdu(gr.basic_block):
          def __init__(self, key_str="1234567890123456"):
              """
              Args:
                  key_str: Must match the Transmitter's key!
              """
              gr.basic_block.__init__(self,
                  name="AES Decrypt PDU",
                  in_sig=None,
                  out_sig=None)

              self.key = key_str.encode('utf-8')[:16].ljust(16, b'\0')
              self.iv = b'\x00' * 16

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              encrypted_bytes = bytes(pmt.u8vector_elements(data_pdu))
              
              if len(encrypted_bytes) == 0:
                  return

              # 1. Decrypt
              cipher = AES.new(self.key, AES.MODE_CBC, self.iv)

              try:
                  # 2. Decrypt and Unpad
                  decrypted_payload = unpad(cipher.decrypt(encrypted_bytes), AES.block_size)
                  
                  # 3. Publish clean data
                  out_vector = pmt.init_u8vector(len(decrypted_payload), list(decrypted_payload))
                  out_msg = pmt.cons(meta, out_vector)
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
              except ValueError:
                  # This happens if decryption fails (e.g. padding error due to corruption)
                  print("[AES Decrypt] Error: Padding incorrect (Packet corrupted?)")
              except Exception as e:
                  print(f"[AES Decrypt] Error: {e}")
    key_str: '''1234567890123456'''
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Sequence Number Checker (IP Support)
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class seq_num_checker(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Sequence Num Checker",
                  in_sig=None,
                  out_sig=None)

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              
              # Output 1: Valid Data (to File Sink)
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Output 2: Request/ACK Trigger (to ACK Generator)
              self.message_port_register_out(pmt.intern("request_out"))

              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # Internal State
              self.rn = 0  # Expected Sequence Number
              print("[RX Checker] Block Initialized. Waiting for Packet 0.")

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = list(pmt.u8vector_elements(data_pdu))
              
              if len(data_bytes) < 1:
                  return 

              # 1. Extract Source IP from Metadata
              # The 'Address & Type Filter' saved this earlier.
              # It is a PMT u8vector (4 bytes).
              src_ip_pmt = pmt.dict_ref(meta, pmt.intern("src_ip"), pmt.PMT_NIL)
              
              if pmt.is_null(src_ip_pmt):
                  # Fallback if metadata is missing (shouldn't happen)
                  # print("[RX Checker] Error: No Source IP in metadata")
                  return

              # 2. Get Sequence Number (First byte of payload)
              sn_received = data_bytes[0]

              # 3. Logic Check
              if sn_received == self.rn:
                  # === MATCH: Valid Packet ===
                  
                  # A. Publish Payload (Strip Sequence Number)
                  payload = data_bytes[1:]
                  if len(payload) > 0:
                      out_vector = pmt.init_u8vector(len(payload), payload)
                      out_msg = pmt.cons(meta, out_vector)
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
                  # B. Update State
                  self.rn = (self.rn + 1) % 256
                  
                  # C. Send ACK (New RN)
                  self.send_ack_request(self.rn, src_ip_pmt)
                  
              else:
                  # === MISMATCH: Duplicate ===
                  # Re-send ACK for the CURRENT RN (Reminder)
                  self.send_ack_request(self.rn, src_ip_pmt)

          def send_ack_request(self, req_num, target_ip_pmt):
              """
              Sends a pair: (Target_IP_PMT . Request_Number_Int)
              """
              msg_pair = pmt.cons(target_ip_pmt, pmt.from_long(req_num))
              self.message_port_pub(pmt.intern("request_out"), msg_pair)
  states: {}
- name: epy_block_4_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Sequence Number Checker (IP Support)
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class seq_num_checker(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Sequence Num Checker",
                  in_sig=None,
                  out_sig=None)

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              
              # Output 1: Valid Data (to File Sink)
              self.message_port_register_out(pmt.intern("pdu_out"))
              
              # Output 2: Request/ACK Trigger (to ACK Generator)
              self.message_port_register_out(pmt.intern("request_out"))

              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # Internal State
              self.rn = 0  # Expected Sequence Number
              print("[RX Checker] Block Initialized. Waiting for Packet 0.")

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = list(pmt.u8vector_elements(data_pdu))
              
              if len(data_bytes) < 1:
                  return 

              # 1. Extract Source IP from Metadata
              # The 'Address & Type Filter' saved this earlier.
              # It is a PMT u8vector (4 bytes).
              src_ip_pmt = pmt.dict_ref(meta, pmt.intern("src_ip"), pmt.PMT_NIL)
              
              if pmt.is_null(src_ip_pmt):
                  # Fallback if metadata is missing (shouldn't happen)
                  # print("[RX Checker] Error: No Source IP in metadata")
                  return

              # 2. Get Sequence Number (First byte of payload)
              sn_received = data_bytes[0]

              # 3. Logic Check
              if sn_received == self.rn:
                  # === MATCH: Valid Packet ===
                  
                  # A. Publish Payload (Strip Sequence Number)
                  payload = data_bytes[1:]
                  if len(payload) > 0:
                      out_vector = pmt.init_u8vector(len(payload), payload)
                      out_msg = pmt.cons(meta, out_vector)
                      self.message_port_pub(pmt.intern("pdu_out"), out_msg)
                  
                  # B. Update State
                  self.rn = (self.rn + 1) % 256
                  
                  # C. Send ACK (New RN)
                  self.send_ack_request(self.rn, src_ip_pmt)
                  
              else:
                  # === MISMATCH: Duplicate ===
                  # Re-send ACK for the CURRENT RN (Reminder)
                  self.send_ack_request(self.rn, src_ip_pmt)

          def send_ack_request(self, req_num, target_ip_pmt):
              """
              Sends a pair: (Target_IP_PMT . Request_Number_Int)
              """
              msg_pair = pmt.cons(target_ip_pmt, pmt.from_long(req_num))
              self.message_port_pub(pmt.intern("request_out"), msg_pair)
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU File Sink (With Append Option)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class pdu_file_sink(gr.basic_block):
          def __init__(self, filename="received_output.txt", append=False):
              gr.basic_block.__init__(self,
                  name="PDU File Sink",
                  in_sig=None,
                  out_sig=None)

              self.filename = filename
              self.append = append
              self.file_handle = None

              # Register Input Port
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # Determine Mode: 'ab' = Append Binary, 'wb' = Write Binary (Overwrite)
              mode = 'ab' if self.append else 'wb'

              try:
                  self.file_handle = open(self.filename, mode)
                  action = "Appending to" if self.append else "Overwriting"
                  print(f"PDU File Sink: {action} {self.filename}")
              except Exception as e:
                  print(f"PDU File Sink Error: Could not open file. {e}")

          def handle_msg(self, msg):
              # 1. Validate PDU
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              data_vector = pmt.cdr(msg)
              
              # 3. Convert to Bytes
              data_bytes = bytearray(pmt.u8vector_elements(data_vector))
              
              # 4. Write to Disk
              if self.file_handle:
                  self.file_handle.write(data_bytes)
                  self.file_handle.flush() # Force save immediately

          def __del__(self):
              if self.file_handle:
                  self.file_handle.close()
    append: 'False'
    filename: '"C:/Users/PC/Desktop/RX_1.txt"'
  states: {}
- name: epy_block_5_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU File Sink (With Append Option)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class pdu_file_sink(gr.basic_block):
          def __init__(self, filename="received_output.txt", append=False):
              gr.basic_block.__init__(self,
                  name="PDU File Sink",
                  in_sig=None,
                  out_sig=None)

              self.filename = filename
              self.append = append
              self.file_handle = None

              # Register Input Port
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # Determine Mode: 'ab' = Append Binary, 'wb' = Write Binary (Overwrite)
              mode = 'ab' if self.append else 'wb'

              try:
                  self.file_handle = open(self.filename, mode)
                  action = "Appending to" if self.append else "Overwriting"
                  print(f"PDU File Sink: {action} {self.filename}")
              except Exception as e:
                  print(f"PDU File Sink Error: Could not open file. {e}")

          def handle_msg(self, msg):
              # 1. Validate PDU
              if not pmt.is_pdu(msg):
                  return

              # 2. Extract Data
              data_vector = pmt.cdr(msg)
              
              # 3. Convert to Bytes
              data_bytes = bytearray(pmt.u8vector_elements(data_vector))
              
              # 4. Write to Disk
              if self.file_handle:
                  self.file_handle.write(data_bytes)
                  self.file_handle.flush() # Force save immediately

          def __del__(self):
              if self.file_handle:
                  self.file_handle.close()
    append: 'False'
    filename: '"C:/Users/PC/Desktop/RX_2.txt"'
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Add Addressing (IP Support)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import socket

      class pdu_add_addressing(gr.basic_block):
          def __init__(self, src_ip="192.168.1.10", dest_ip="192.168.1.20"):
              """
              Args:
                  src_ip: Source IP Address (String, e.g., "192.168.1.10")
                  dest_ip: Destination IP Address (String)
              """
              gr.basic_block.__init__(self,
                  name="PDU Add Addressing",
                  in_sig=None,
                  out_sig=None)

              # Convert IP Strings to 4-byte binary format
              # inet_aton converts "192.168.1.1" -> b'\xc0\xa8\x01\x01'
              try:
                  self.src_bytes = socket.inet_aton(src_ip)
                  self.dest_bytes = socket.inet_aton(dest_ip)
              except OSError:
                  print(f"[Error] Invalid IP Address format: {src_ip} or {dest_ip}")
                  self.src_bytes = b'\x00\x00\x00\x00'
                  self.dest_bytes = b'\x00\x00\x00\x00'

              self.TYPE_DATA = 0  # Type 0 = Data Message

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = bytearray(pmt.u8vector_elements(data_pdu))

              # Create Header
              # Structure: [ Dest (4B) ] [ Src (4B) ] [ TYPE (1B) ]
              # '4s' means a string of 4 bytes. 'B' means 1 unsigned byte.
              header = struct.pack('!4s4sB', self.dest_bytes, self.src_bytes, self.TYPE_DATA)

              # Prepend Header to Data
              # Result: [Dest 4B] [Src 4B] [Type=0] [Seq Num] [Payload]
              new_data = header + data_bytes

              # Publish
              out_vector = pmt.init_u8vector(len(new_data), list(new_data))
              out_msg = pmt.cons(meta, out_vector)
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    dest_ip: '"192.168.1.20"'
    src_ip: '"192.168.1.10"'
  states: {}
- name: epy_block_6_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: PDU Add Addressing (IP Support)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import socket

      class pdu_add_addressing(gr.basic_block):
          def __init__(self, src_ip="192.168.1.10", dest_ip="192.168.1.20"):
              """
              Args:
                  src_ip: Source IP Address (String, e.g., "192.168.1.10")
                  dest_ip: Destination IP Address (String)
              """
              gr.basic_block.__init__(self,
                  name="PDU Add Addressing",
                  in_sig=None,
                  out_sig=None)

              # Convert IP Strings to 4-byte binary format
              # inet_aton converts "192.168.1.1" -> b'\xc0\xa8\x01\x01'
              try:
                  self.src_bytes = socket.inet_aton(src_ip)
                  self.dest_bytes = socket.inet_aton(dest_ip)
              except OSError:
                  print(f"[Error] Invalid IP Address format: {src_ip} or {dest_ip}")
                  self.src_bytes = b'\x00\x00\x00\x00'
                  self.dest_bytes = b'\x00\x00\x00\x00'

              self.TYPE_DATA = 0  # Type 0 = Data Message

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pdu(msg):
                  return

              meta = pmt.car(msg)
              data_pdu = pmt.cdr(msg)
              data_bytes = bytearray(pmt.u8vector_elements(data_pdu))

              # Create Header
              # Structure: [ Dest (4B) ] [ Src (4B) ] [ TYPE (1B) ]
              # '4s' means a string of 4 bytes. 'B' means 1 unsigned byte.
              header = struct.pack('!4s4sB', self.dest_bytes, self.src_bytes, self.TYPE_DATA)

              # Prepend Header to Data
              # Result: [Dest 4B] [Src 4B] [Type=0] [Seq Num] [Payload]
              new_data = header + data_bytes

              # Publish
              out_vector = pmt.init_u8vector(len(new_data), list(new_data))
              out_msg = pmt.cons(meta, out_vector)
              self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    dest_ip: '"192.168.1.10"'
    src_ip: '"192.168.1.20"'
  states: {}
- name: epy_block_7_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Address & Type Filter (IP Support)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import socket

      class addr_type_filter(gr.basic_block):
          def __init__(self, my_ip="192.168.1.20"):
              """
              Args:
                  my_ip: The IP address of THIS receiver (String).
              """
              gr.basic_block.__init__(self,
                  name="Address & Type Filter",
                  in_sig=None,
                  out_sig=None)

              self.my_ip_str = my_ip
              
              # Convert IP string to 4-byte binary
              try:
                  self.my_ip_bytes = list(socket.inet_aton(self.my_ip_str))
              except OSError:
                  print(f"[Error] Invalid IP format: {my_ip}")
                  self.my_ip_bytes = [0, 0, 0, 0]

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              
              # Output 1: Data PDUs (Goes to Sequence Checker)
              self.message_port_register_out(pmt.intern("data_out"))
              
              # Output 2: ACK Integers (Goes DIRECTLY to PDU Storage 'request_in')
              self.message_port_register_out(pmt.intern("ack_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              data_pdu = pmt.cdr(msg)
              data_bytes = list(pmt.u8vector_elements(data_pdu))

              # 2. Safety Check
              # Header: [Dest 4B] [Src 4B] [Type 1B] [Seq/RN 1B] ...
              # We need at least 10 bytes to process a valid packet
              if len(data_bytes) < 10:
                  return

              # 3. Check Destination (Bytes 0-3)
              dest_received = data_bytes[0:4]
              
              if dest_received != self.my_ip_bytes:
                  # Not for us -> Drop it
                  return

              # 4. Extract Header Info
              src_received = data_bytes[4:8]
              pkt_type     = data_bytes[8]
              seq_or_rn    = data_bytes[9]

              # 5. Logic Branch
              if pkt_type == 0:
                  # === CASE: DATA MESSAGE ===
                  # We need to send [Seq Num] [Payload] to the Sequence Checker.
                  # We strip the first 9 bytes (Dest, Src, Type).
                  # We KEEP the Seq Num (Byte 9) because Sequence Checker needs it.
                  clean_payload = data_bytes[9:] 
                  
                  # Save Source IP to Metadata (Required for replying with ACK)
                  meta = pmt.car(msg)
                  src_ip_pmt = pmt.init_u8vector(4, src_received)
                  meta = pmt.dict_add(meta, pmt.intern("src_ip"), src_ip_pmt)
                  
                  # Create PDU
                  out_vector = pmt.init_u8vector(len(clean_payload), clean_payload)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # Send to Sequence Checker
                  self.message_port_pub(pmt.intern("data_out"), out_msg)

              elif pkt_type == 1:
                  # === CASE: ACKNOWLEDGMENT ===
                  # The 'seq_or_rn' byte IS the Request Number we need.
                  # We don't need a PDU here; PDU Storage expects a simple Integer.
                  
                  # Create PMT Integer
                  ack_msg = pmt.from_long(seq_or_rn)
                  
                  # Send to PDU Storage (request_in)
                  self.message_port_pub(pmt.intern("ack_out"), ack_msg)
                  # print(f"[RX Filter] Received ACK {seq_or_rn} from {src_received}")
    my_ip: '"192.168.1.10"'
  states: {}
- name: epy_block_7_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Address & Type Filter (IP Support)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import socket

      class addr_type_filter(gr.basic_block):
          def __init__(self, my_ip="192.168.1.20"):
              """
              Args:
                  my_ip: The IP address of THIS receiver (String).
              """
              gr.basic_block.__init__(self,
                  name="Address & Type Filter",
                  in_sig=None,
                  out_sig=None)

              self.my_ip_str = my_ip
              
              # Convert IP string to 4-byte binary
              try:
                  self.my_ip_bytes = list(socket.inet_aton(self.my_ip_str))
              except OSError:
                  print(f"[Error] Invalid IP format: {my_ip}")
                  self.my_ip_bytes = [0, 0, 0, 0]

              # Register Ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              
              # Output 1: Data PDUs (Goes to Sequence Checker)
              self.message_port_register_out(pmt.intern("data_out"))
              
              # Output 2: ACK Integers (Goes DIRECTLY to PDU Storage 'request_in')
              self.message_port_register_out(pmt.intern("ack_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              # 1. Validate Input
              if not pmt.is_pdu(msg):
                  return

              data_pdu = pmt.cdr(msg)
              data_bytes = list(pmt.u8vector_elements(data_pdu))

              # 2. Safety Check
              # Header: [Dest 4B] [Src 4B] [Type 1B] [Seq/RN 1B] ...
              # We need at least 10 bytes to process a valid packet
              if len(data_bytes) < 10:
                  return

              # 3. Check Destination (Bytes 0-3)
              dest_received = data_bytes[0:4]
              
              if dest_received != self.my_ip_bytes:
                  # Not for us -> Drop it
                  return

              # 4. Extract Header Info
              src_received = data_bytes[4:8]
              pkt_type     = data_bytes[8]
              seq_or_rn    = data_bytes[9]

              # 5. Logic Branch
              if pkt_type == 0:
                  # === CASE: DATA MESSAGE ===
                  # We need to send [Seq Num] [Payload] to the Sequence Checker.
                  # We strip the first 9 bytes (Dest, Src, Type).
                  # We KEEP the Seq Num (Byte 9) because Sequence Checker needs it.
                  clean_payload = data_bytes[9:] 
                  
                  # Save Source IP to Metadata (Required for replying with ACK)
                  meta = pmt.car(msg)
                  src_ip_pmt = pmt.init_u8vector(4, src_received)
                  meta = pmt.dict_add(meta, pmt.intern("src_ip"), src_ip_pmt)
                  
                  # Create PDU
                  out_vector = pmt.init_u8vector(len(clean_payload), clean_payload)
                  out_msg = pmt.cons(meta, out_vector)
                  
                  # Send to Sequence Checker
                  self.message_port_pub(pmt.intern("data_out"), out_msg)

              elif pkt_type == 1:
                  # === CASE: ACKNOWLEDGMENT ===
                  # The 'seq_or_rn' byte IS the Request Number we need.
                  # We don't need a PDU here; PDU Storage expects a simple Integer.
                  
                  # Create PMT Integer
                  ack_msg = pmt.from_long(seq_or_rn)
                  
                  # Send to PDU Storage (request_in)
                  self.message_port_pub(pmt.intern("ack_out"), ack_msg)
                  # print(f"[RX Filter] Received ACK {seq_or_rn} from {src_received}")
    my_ip: '"192.168.1.20"'
  states: {}
- name: epy_block_8_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Generator (No Preamble, IP + Type Support)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import time
      import socket

      class ack_generator(gr.basic_block):
          def __init__(self, my_ip="192.168.1.20", payload_len=100, ack_interval=0.1):
              """
              Args:
                  my_ip: The IP of THIS receiver.
                  payload_len: Padding length.
                  ack_interval: Throttling time for duplicate ACKs.
              """
              gr.basic_block.__init__(self,
                  name="ACK Generator",
                  in_sig=None,
                  out_sig=None)

              self.p_len = payload_len
              self.interval = ack_interval
              
              # Constant: Type 1 = ACK
              self.MSG_TYPE_ACK = 1

              # Convert My IP to Bytes
              try:
                  self.my_ip_bytes = socket.inet_aton(my_ip)
              except OSError:
                  print(f"[ACK Gen] Error: Invalid IP {my_ip}")
                  self.my_ip_bytes = b'\x00\x00\x00\x00'

              # State
              self.last_dest_ip = None
              self.last_rn = -1
              self.last_time = 0.0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return

              # Extract Target IP and Request Number
              target_ip_pmt = pmt.car(msg)
              req_num = pmt.to_long(pmt.cdr(msg))
              
              if pmt.is_u8vector(target_ip_pmt):
                  target_ip_bytes = bytes(pmt.u8vector_elements(target_ip_pmt))
              else:
                  return

              now = time.time()
              should_send = False

              # Throttling Logic
              if (target_ip_bytes == self.last_dest_ip) and (req_num == self.last_rn):
                  if (now - self.last_time) >= self.interval:
                      should_send = True
              else:
                  should_send = True

              if should_send:
                  self.last_dest_ip = target_ip_bytes
                  self.last_rn = req_num
                  self.last_time = now
                  
                  # --- Create Header ---
                  # Format: [ Dest(4B) ] [ Src(4B) ] [ Type(1B) ] [ RN(1B) ]
                  # We set Type to 1 (self.MSG_TYPE_ACK)
                  header = struct.pack('!4s4sBB', target_ip_bytes, self.my_ip_bytes, self.MSG_TYPE_ACK, req_num)

                  # --- Create Payload ---
                  # Padding to keep transmitter on air (using 0x55 pattern)
                  payload = b'\x55' * self.p_len
                  
                  # --- Combine (No Preamble) ---
                  full_data = header + payload

                  # --- Publish ---
                  meta = pmt.make_dict()
                  out_vector = pmt.init_u8vector(len(full_data), list(full_data))
                  out_msg = pmt.cons(meta, out_vector)

                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    ack_interval: '0.5'
    my_ip: '"192.168.1.10"'
    payload_len: '32'
  states: {}
- name: epy_block_8_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ACK Generator (No Preamble, IP + Type Support)
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      import time
      import socket

      class ack_generator(gr.basic_block):
          def __init__(self, my_ip="192.168.1.20", payload_len=100, ack_interval=0.1):
              """
              Args:
                  my_ip: The IP of THIS receiver.
                  payload_len: Padding length.
                  ack_interval: Throttling time for duplicate ACKs.
              """
              gr.basic_block.__init__(self,
                  name="ACK Generator",
                  in_sig=None,
                  out_sig=None)

              self.p_len = payload_len
              self.interval = ack_interval
              
              # Constant: Type 1 = ACK
              self.MSG_TYPE_ACK = 1

              # Convert My IP to Bytes
              try:
                  self.my_ip_bytes = socket.inet_aton(my_ip)
              except OSError:
                  print(f"[ACK Gen] Error: Invalid IP {my_ip}")
                  self.my_ip_bytes = b'\x00\x00\x00\x00'

              # State
              self.last_dest_ip = None
              self.last_rn = -1
              self.last_time = 0.0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return

              # Extract Target IP and Request Number
              target_ip_pmt = pmt.car(msg)
              req_num = pmt.to_long(pmt.cdr(msg))
              
              if pmt.is_u8vector(target_ip_pmt):
                  target_ip_bytes = bytes(pmt.u8vector_elements(target_ip_pmt))
              else:
                  return

              now = time.time()
              should_send = False

              # Throttling Logic
              if (target_ip_bytes == self.last_dest_ip) and (req_num == self.last_rn):
                  if (now - self.last_time) >= self.interval:
                      should_send = True
              else:
                  should_send = True

              if should_send:
                  self.last_dest_ip = target_ip_bytes
                  self.last_rn = req_num
                  self.last_time = now
                  
                  # --- Create Header ---
                  # Format: [ Dest(4B) ] [ Src(4B) ] [ Type(1B) ] [ RN(1B) ]
                  # We set Type to 1 (self.MSG_TYPE_ACK)
                  header = struct.pack('!4s4sBB', target_ip_bytes, self.my_ip_bytes, self.MSG_TYPE_ACK, req_num)

                  # --- Create Payload ---
                  # Padding to keep transmitter on air (using 0x55 pattern)
                  payload = b'\x55' * self.p_len
                  
                  # --- Combine (No Preamble) ---
                  full_data = header + payload

                  # --- Publish ---
                  meta = pmt.make_dict()
                  out_vector = pmt.init_u8vector(len(full_data), list(full_data))
                  out_msg = pmt.cons(meta, out_vector)

                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)
    ack_interval: '0.5'
    my_ip: '"192.168.1.20"'
    payload_len: '32'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    dev_args: '0'
    gain: '60'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    dev_args: '0'
    gain: '60'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '9000'
    center_freq: freq
    dev_args: '0'
    gain: '30'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '9000'
    center_freq: freq
    dev_args: '0'
    gain: '30'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}

connections:
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_2, '0', blocks_throttle2_0_2, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_tagged_stream_mux_0_1, '0', blocks_repack_bits_bb_1_0_2, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_1, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_1_1, '0', channels_channel_model_0_1, '0']
- [blocks_throttle2_0_2, '0', digital_constellation_modulator_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0_0_0, '0']
- [channels_channel_model_0_1, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_constellation_modulator_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_throttle2_0_1_1, '0']
- [digital_constellation_modulator_0_1, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_constellation_modulator_0_1, '0', qtgui_freq_sink_x_1_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_crc_append_0, out, epy_block_12, data_in]
- [digital_crc_append_0_0_0, out, epy_block_12, ack_in]
- [digital_crc_append_0_0_0_0, out, epy_block_12_1, ack_in]
- [digital_crc_append_0_1, out, epy_block_12_1, data_in]
- [digital_crc_check_0_0, ok, epy_block_7_1, pdu_in]
- [digital_crc_check_0_0_0, ok, epy_block_7_1_0, pdu_in]
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_1, header, pdu_pdu_to_tagged_stream_0_2, pdus]
- [digital_protocol_formatter_async_0_1, payload, pdu_pdu_to_tagged_stream_0_0_1, pdus]
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [epy_block_0, pdu_out, epy_block_2_1, pdu_in]
- [epy_block_0_1, pdu_out, epy_block_2_1_0, pdu_in]
- [epy_block_1, pdu_out, epy_block_6, pdu_in]
- [epy_block_10, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_10_1, pdu_out, digital_protocol_formatter_async_0_1, in]
- [epy_block_11_0, pdu_out, epy_block_3_0, pdu_in]
- [epy_block_11_0_0, pdu_out, epy_block_3_0_0, pdu_in]
- [epy_block_12, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_12, pdu_out, epy_block_2, pdu_in]
- [epy_block_12_1, pdu_out, digital_protocol_formatter_async_0_1, in]
- [epy_block_12_1, pdu_out, epy_block_2_2, pdu_in]
- [epy_block_1_0, pdu_out, epy_block_6_0, pdu_in]
- [epy_block_2, pdu_out, epy_block_10, pdu_in]
- [epy_block_2_1, pdu_out, epy_block_1, pdu_in]
- [epy_block_2_1_0, pdu_out, epy_block_1_0, pdu_in]
- [epy_block_2_2, pdu_out, epy_block_10_1, pdu_in]
- [epy_block_3_0, pdu_out, digital_crc_check_0_0, in]
- [epy_block_3_0_0, pdu_out, digital_crc_check_0_0_0, in]
- [epy_block_3_1_0, pdu_out, epy_block_5_0, pdu_in]
- [epy_block_3_1_0_0, pdu_out, epy_block_5_0_0, pdu_in]
- [epy_block_4_0, pdu_out, epy_block_3_1_0, pdu_in]
- [epy_block_4_0, request_out, epy_block_8_0, msg_in]
- [epy_block_4_0_0, pdu_out, epy_block_3_1_0_0, pdu_in]
- [epy_block_4_0_0, request_out, epy_block_8_0_0, msg_in]
- [epy_block_6, pdu_out, digital_crc_append_0, in]
- [epy_block_6_0, pdu_out, digital_crc_append_0_1, in]
- [epy_block_7_1, ack_out, blocks_message_debug_0, print]
- [epy_block_7_1, ack_out, epy_block_1, request_in]
- [epy_block_7_1, data_out, epy_block_4_0, pdu_in]
- [epy_block_7_1_0, ack_out, blocks_message_debug_0_1, print]
- [epy_block_7_1_0, ack_out, epy_block_1_0, request_in]
- [epy_block_7_1_0, data_out, epy_block_4_0_0, pdu_in]
- [epy_block_8_0, pdu_out, digital_crc_append_0_0_0, in]
- [epy_block_8_0_0, pdu_out, digital_crc_append_0_0_0_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_1, '0', blocks_tagged_stream_mux_0_1, '1']
- [pdu_pdu_to_tagged_stream_0_2, '0', blocks_tagged_stream_mux_0_1, '0']
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, epy_block_11_0, pdu_in]
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, digital_crc_check_0_0_0, in]
- [pdu_tagged_stream_to_pdu_0_0_0_0, pdus, epy_block_11_0_0, pdu_in]
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0_0, '0', digital_symbol_sync_xx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
