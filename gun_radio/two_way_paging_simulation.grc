<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
  <options>
    <title>Two-Way Paging System (Simulation)</title>
    <author>ChatGPT</author>
    <description>Starter GRC for text message paging with BPSK, CRC, addressing, and ACK simulation.</description>
    <generate_options>qt_gui</generate_options>
    <category>Custom</category>
    <realtime_scheduling>off</realtime_scheduling>
    <run_options>prompt</run_options>
    <thread_safe_set>default</thread_safe_set>
  </options>

  <!-- Message Source -->
  <block>
    <key>blocks_message_strobe</key>
    <param><key>msg</key><value>pmt.intern("Hello123")</value></param>
    <param><key>period</key><value>1000</value></param>
    <param><key>alias</key><value>MsgSource</value></param>
  </block>

  <!-- PDU to Tagged Stream -->
  <block>
    <key>blocks_pdu_to_tagged_stream</key>
    <param><key>mtu</key><value>1500</value></param>
    <param><key>tagname</key><value>packet_len</value></param>
  </block>

  <!-- CRC Append -->
  <block>
    <key>digital_crc32_async_bb</key>
    <param><key>check</key><value>False</value></param>
  </block>

  <!-- BPSK Modulator -->
  <block>
    <key>digital_constellation_modulator</key>
    <param><key>constellation</key><value>digital.constellation_bpsk().base()</value></param>
    <param><key>samples_per_symbol</key><value>4</value></param>
    <param><key>excess_bw</key><value>0.35</value></param>
  </block>

  <!-- Channel Model -->
  <block>
    <key>channels_channel_model</key>
    <param><key>noise_voltage</key><value>0.1</value></param>
    <param><key>frequency_offset</key><value>0.01</value></param>
    <param><key>epsilon</key><value>1.0</value></param>
  </block>

  <!-- BPSK Demodulator -->
  <block>
    <key>digital_constellation_decoder_cb</key>
    <param><key>constellation</key><value>digital.constellation_bpsk().base()</value></param>
  </block>

  <!-- CRC Check -->
  <block>
    <key>digital_crc32_async_bb</key>
    <param><key>check</key><value>True</value></param>
  </block>

  <!-- Message Debug -->
  <block>
    <key>blocks_message_debug</key>
  </block>

  <!-- GUI Sink -->
  <block>
    <key>qtgui_const_sink_x</key>
    <param><key>type</key><value>complex</value></param>
    <param><key>samp_rate</key><value>32000</value></param>
    <param><key>name</key><value>Constellation</value></param>
    <param><key>size</key><value>1024</value></param>
    <param><key>nconnections</key><value>1</value></param>
  </block>
</flow_graph>
