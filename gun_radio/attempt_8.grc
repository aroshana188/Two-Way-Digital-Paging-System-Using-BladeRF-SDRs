options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_8
    output_language: python
    title: pkt_8
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class AckNackGenerator(gr.basic_block):
          """
          Simple ACK/NACK Generator.
          - Receives messages on "ok_in" or "fail_in".
          - Outputs "ack" or "nack" symbols on "out".
          Compatible with PDUFileSource's ctrl_in port.
          """

          def __init__(self):
              gr.basic_block.__init__(self, name="ACK/NACK Generator", in_sig=[], out_sig=[])

              # Input ports
              self.message_port_register_in(pmt.intern("ok_in"))
              self.set_msg_handler(pmt.intern("ok_in"), self.handle_ok)

              self.message_port_register_in(pmt.intern("fail_in"))
              self.set_msg_handler(pmt.intern("fail_in"), self.handle_fail)

              # Output port (to file source ctrl_in)
              self.message_port_register_out(pmt.intern("out"))

          def handle_ok(self, msg):
              print(f"[ACK/NACK] Sending ACK")
              self.message_port_pub(pmt.intern("out"), pmt.intern("ack"))

          def handle_fail(self, msg):
              print(f"[ACK/NACK] Sending NACK")
              self.message_port_pub(pmt.intern("out"), pmt.intern("nack"))
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class TaggedStreamToFile(gr.basic_block):
          """
          Writes incoming PDUs (Tagged Stream converted to PDU) into a file,
          including metadata. Appends all incoming PDUs sequentially.
          """

          def __init__(self, filename="C:/Users/arosh/OneDrive/Desktop/output.txt"):
              gr.basic_block.__init__(
                  self,
                  name="TaggedStreamToFile",
                  in_sig=[],
                  out_sig=[]
              )
              self.filename = filename

              # Register message input port
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              # msg is a PDU = (metadata dict, data vector)
              meta = pmt.car(msg)        # metadata dictionary
              data = pmt.cdr(msg)        # u8vector payload

              # Convert data to Python bytes
              data_bytes = bytes(pmt.u8vector_elements(data))

              # Convert metadata to string
              try:
                  meta_str = pmt.write_string(meta)
              except:
                  meta_str = str(meta)

              # Append to file
              with open(self.filename, "ab") as f:
                  f.write(b"==== NEW PACKET ====\n")
                  f.write(f"Metadata: {meta_str}\n".encode())
                  f.write(b"Payload: " + data_bytes + b"\n\n")
    filename: r"C:\Users\PC\University\Semester_3\EN2130_Communication Design Project\Project\apple2.txt"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # PDUFileARQ.py
      from gnuradio import gr
      import pmt
      import os

      class PDUFileARQ(gr.basic_block):
          def __init__(self, file_path="", pdu_size=256):
              gr.basic_block.__init__(
                  self,
                  name="PDUFileARQ",
                  in_sig=None,
                  out_sig=None
              )

              self.file_path = file_path
              self.pdu_size = int(pdu_size) if pdu_size else 256

              # Load file and chunk into list[list[int]]
              self.pdus = []
              if self.file_path and os.path.isfile(self.file_path):
                  with open(self.file_path, "rb") as f:
                      data = f.read()
                  self.pdus = [list(data[i:i+self.pdu_size])
                               for i in range(0, len(data), self.pdu_size)]
              else:
                  if self.file_path:
                      print(f"[ERROR] File not found: {self.file_path}")

              self.current_index = 0
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.message_port_register_in(pmt.intern("control_in"))
              self.set_msg_handler(pmt.intern("control_in"), self.handle_control_msg)

              print(f"[INFO] PDUFileARQ initialized. {len(self.pdus)} PDUs loaded.")

          def start(self):
              # Send the first PDU automatically when flowgraph starts
              if self.pdus:
                  self._publish_current_pdu()
              return True

          def _publish_current_pdu(self):
              """Send current PDU as a proper (meta, data) pair."""
              if not (0 <= self.current_index < len(self.pdus)):
                  return
              pdu_list = self.pdus[self.current_index]
              vec = pmt.init_u8vector(len(pdu_list), pdu_list)
              msg = pmt.cons(pmt.PMT_NIL, vec)
              self.message_port_pub(pmt.intern("pdus_out"), msg)
              print(f"[DEBUG] Sent PDU index={self.current_index}, size={len(pdu_list)}")

          def handle_control_msg(self, msg_pmt):
              """Handle ack/nack control messages (PMT symbol or (meta, symbol) pair)."""
              command = None

              # Case 1: message is a symbol
              if pmt.is_symbol(msg_pmt):
                  command = pmt.symbol_to_string(msg_pmt)

              # Case 2: message is a pair (meta, symbol)
              elif pmt.is_pair(msg_pmt):
                  payload = pmt.cdr(msg_pmt)
                  if pmt.is_symbol(payload):
                      command = pmt.symbol_to_string(payload)

              if command is None:
                  print("[WARNING] Unknown control message format. Ignored.")
                  return

              command = command.lower().strip()
              if command == "ack":
                  if self.current_index < len(self.pdus) - 1:
                      self.current_index += 1
                      self._publish_current_pdu()
                  else:
                      print("[INFO] All PDUs acknowledged.")
              elif command == "nack":
                  print("[DEBUG] NACK received – resending current PDU")
                  self._publish_current_pdu()
              else:
                  print(f"[WARNING] Unknown control command '{command}'")
    file_path: r"C:\Users\PC\University\Semester_3\EN2130_Communication Design Project\Project\apple.txt"
    pdu_size: '256'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pkt_out
  states: {}

connections:
- [blocks_repack_bits_bb_1_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_crc_append_0, out, blocks_message_debug_0, print]
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_check_0, fail, epy_block_0, fail_in]
- [digital_crc_check_0, ok, epy_block_0, ok_in]
- [digital_crc_check_0, ok, epy_block_0_0, in]
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0, out, epy_block_1, control_in]
- [epy_block_1, pdus_out, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [virtual_source_0, '0', blocks_repack_bits_bb_1_0, '0']
- [virtual_source_1, '0', blocks_uchar_to_float_0_0, '0']
- [virtual_source_1, '0', digital_correlate_access_code_xx_ts_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
