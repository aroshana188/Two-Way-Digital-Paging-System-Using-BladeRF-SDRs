options:
  parameters:
    author: Telelink
    category: Custom
    copyright: Telelink
    description: cdp project
    generate_options: qt_gui
    id: Telelink
    output_language: python
    title: Telelink_cdp
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '1'
    padding: 'True'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '42'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 100e3
    stop: 6e9
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '0'
    step: '1'
    stop: '50'
    value: '40'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.001'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rf_gain_sink
  id: variable_qtgui_range
  parameters:
    label: RF gain sink
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rx_freq_
  id: variable
  parameters:
    comment: Set rx frequency
    value: 433e6
  states: {}
- name: rxbw
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: tx_freq
  id: variable
  parameters:
    comment: Set tx frequency
    value: 600e6
  states: {}
- name: txbw
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    start: '18'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: ''
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    comment: prepare to match time sink
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Blade RF delay = 139
    delay: delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"C:/Users/PC/Desktop/Output.txt"'
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '"C:/Users/PC/Desktop/Output2.txt"'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"C:/Users/PC/Desktop/Input.txt"'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '8'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: spr
    type: byte
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class crc_fail_logger(gr.basic_block):
          def __init__(self, log_file=''):
              gr.basic_block.__init__(self,
                  name="CRC Fail Logger",
                  in_sig=None,
                  out_sig=None)

              # INPUT: Connect this to the 'fail' port of the CRC Check block
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              
              self.fail_count = 0
              
              # LOGGING SETUP
              self.log_file_path = log_file
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- CRC FAILURE LOG START ---\n")
                  except: pass

          def log(self, message):
              """Helper function to Print AND Write to file"""
              print(message)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          timestamp = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{timestamp}] {message}\n")
                  except: pass

          def handle_msg(self, msg):
              try:
                  self.fail_count += 1
                  
                  # Extract the length of the bad packet just for info
                  payload = pmt.cdr(msg)
                  data_len = len(pmt.u8vector_elements(payload))
                  
                  self.log(f"[CRC FAIL] Corrupted Packet Dropped! (Size: {data_len} bytes | Total Fails: {self.fail_count})")
                  
              except Exception as e:
                  self.log(f"[CRC Log Error] {e}")
    log_file: '"C:/Users/PC/Desktop/Receiver log.txt"'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import threading
      import os

      class pdu_storage_buffer(gr.basic_block):
          def __init__(self, timeout=1.0, max_retries=5, log_file=''):
              gr.basic_block.__init__(self,
                  name="PDU Storage",
                  in_sig=None,
                  out_sig=None)

              # PORTS
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_incoming_pdu)

              self.message_port_register_in(pmt.intern("request_in"))
              self.set_msg_handler(pmt.intern("request_in"), self.handle_request)

              self.message_port_register_out(pmt.intern("pdu_out"))

              # STORAGE & STATE
              self.pdu_storage = {}
              self.in_preamble_phase = True
              
              # TIMEOUT PARAMETERS
              self.timeout = timeout
              self.max_retries = max_retries
              
              # TIMEOUT STATE
              self.current_seq_waiting = 0 
              self.retry_count = 0
              self.last_tx_time = time.time()
              
              # LOGGING SETUP
              self.log_file_path = log_file
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- ARQ STORAGE LOG START ---\n")
                  except: pass
              
              # THREADING
              self.stop_thread = False
              self.thread = threading.Thread(target=self.timer_loop)
              self.thread.daemon = True

          def start(self):
              self.stop_thread = False
              self.thread.start()
              return True

          def stop(self):
              self.stop_thread = True
              self.thread.join()
              return True

          def log(self, message):
              print(message)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          timestamp = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{timestamp}] {message}\n")
                  except: pass

          def handle_incoming_pdu(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  data = pmt.u8vector_elements(payload)
                  if len(data) < 1: return
                  seq_num = data[0]
                  
                  # Store PDU
                  self.pdu_storage[seq_num] = msg

                  # PREAMBLE LOGIC
                  if self.in_preamble_phase:
                      self.log(f"[PDU Storage Buffer]        Preamble/Init #{seq_num} sending.")
                      self.message_port_pub(pmt.intern("pdu_out"), msg)
                      
                      if seq_num == 0:
                          self.in_preamble_phase = False
                          self.current_seq_waiting = 0
                          self.reset_timer()

              except Exception as e:
                  self.log(f"[PDU Storage Error] Store: {e}")

          def handle_request(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  data = pmt.u8vector_elements(payload)
                  if len(data) < 1: return
                  
                  req_seq = data[0]

                  # --- FIX: GHOST ACK PROTECTION ---
                  diff = (req_seq - self.current_seq_waiting + 256) % 256
                  
                  if diff > 128:
                      self.log(f"[PDU Storage Ignore]      Ignoring old request for #{req_seq} (I am at #{self.current_seq_waiting})")
                      return
                  # --------------------------------

                  # UPDATE STATE
                  if req_seq != self.current_seq_waiting:
                      self.log(f"[PDU Storage Buffer]        ACK received! Moving target to #{req_seq}")
                      self.current_seq_waiting = req_seq
                      self.reset_timer() 
                      
                      # --- COMPLETION CHECK ---
                      # If we moved to a sequence number we don't have yet, 
                      # it means we finished everything currently in the buffer.
                      if self.current_seq_waiting not in self.pdu_storage:
                          self.log(f"[PDU Storage Info] All packets sent & ACKed. Transmission Complete.")

                  # SEND IMMEDIATELY
                  if req_seq in self.pdu_storage:
                      self.send_pdu(req_seq)
                  else:
                      pass

              except Exception as e:
                  self.log(f"[PDU Storage Error] Request: {e}")

          def send_pdu(self, seq_num):
              if seq_num in self.pdu_storage:
                  self.message_port_pub(pmt.intern("pdu_out"), self.pdu_storage[seq_num])
                  self.last_tx_time = time.time() 

          def reset_timer(self):
              self.retry_count = 0
              self.last_tx_time = time.time()

          def timer_loop(self):
              time.sleep(2.0)
              
              while not self.stop_thread:
                  time.sleep(0.1) 
                  
                  if self.in_preamble_phase:
                      continue

                  now = time.time()
                  if (now - self.last_tx_time) > self.timeout:
                      
                      if self.retry_count < self.max_retries:
                          if self.current_seq_waiting in self.pdu_storage:
                              self.log(f"[PDU Storage Timeout]       Resending #{self.current_seq_waiting} (Attempt {self.retry_count + 1}/{self.max_retries})")
                              self.send_pdu(self.current_seq_waiting)
                              self.retry_count += 1
                          else:
                              self.last_tx_time = time.time()
                              
                      else:
                          # MAX RETRIES REACHED -> SKIP
                          self.log(f"[PDU Storage Skip]          Max retries failed for #{self.current_seq_waiting}. Skipping.")
                          
                          # Move to next sequence number
                          self.current_seq_waiting = (self.current_seq_waiting + 1) % 256
                          
                          # Reset retries for the NEW target
                          self.retry_count = 0
                          
                          # Send immediate update
                          if self.current_seq_waiting in self.pdu_storage:
                              self.log(f"[PDU Storage Skip]          Sending new target #{self.current_seq_waiting}")
                              self.send_pdu(self.current_seq_waiting)
                          else:
                              self.last_tx_time = time.time()
                              # --- COMPLETION CHECK (ON SKIP) ---
                              self.log(f"[PDU Storage Info] Skipped to end. Transmission Complete (Buffer Empty).")
    log_file: '"C:/Users/PC/Desktop/Transmitter log.txt"'
    max_retries: '1'
    timeout: '1'
  states: {state: disabled}
- name: epy_block_12
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import threading

      class pdu_file_source(gr.basic_block):
          def __init__(self, file_path='/home/user/test.txt', pdu_size=50, interval=1.0, flush_count=10, preamble_count=20, log_file=''):
              gr.basic_block.__init__(self,
                  name="File Source",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern("pdu_out"))

              self.file_path = file_path
              self.pdu_size = pdu_size
              self.interval = interval
              self.flush_count = flush_count
              self.preamble_count = preamble_count
              self.log_file_path = log_file
              
              self.seq_num = 0
              self.stop_thread = False
              self.thread = threading.Thread(target=self.run)
              self.thread.daemon = True

              # Init Log
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- TX SOURCE LOG START ---\n")
                  except: pass

          def log(self, msg):
              print(msg)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          t = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{t}] {msg}\n")
                  except: pass

          def start(self):
              self.stop_thread = False
              self.thread.start()
              return True

          def stop(self):
              self.stop_thread = True
              self.thread.join()
              return True

          def send_dummy_packet(self, capacity):
              dummy_payload = [self.seq_num] + ([0] * capacity)
              data_pmt = pmt.init_u8vector(len(dummy_payload), dummy_payload)
              pdu_msg = pmt.cons(pmt.PMT_NIL, data_pmt)
              self.message_port_pub(pmt.intern("pdu_out"), pdu_msg)
              self.seq_num = (self.seq_num + 1) % 256
              time.sleep(self.interval)

          def run(self):
              time.sleep(2.0) 
              data_capacity = self.pdu_size - 1

              self.log(f"[File Source]	       Sending {self.preamble_count} Preamble packets...")
              self.seq_num = (256 - self.preamble_count) % 256
              
              for _ in range(self.preamble_count):
                  if self.stop_thread: break
                  self.send_dummy_packet(data_capacity)

              # --- PART 1: SEND FILE ---
              try:
                  with open(self.file_path, 'rb') as f:
                      file_data = f.read()
              except Exception as e:
                  self.log(f"[File Source Error] {e}")
                  return

              total_len = len(file_data)
              cursor = 0
              self.log(f"[File Source]	       Starting File Transmission (Packet #{self.seq_num})...")

              while not self.stop_thread and cursor < total_len:
                  end_pointer = min(cursor + data_capacity, total_len)
                  data_chunk = file_data[cursor : end_pointer]
                  actual_len = len(data_chunk)
                  padding_list = [0] * (data_capacity - actual_len)

                  payload_bytes = [self.seq_num] + list(data_chunk) + padding_list
                  data_pmt = pmt.init_u8vector(len(payload_bytes), payload_bytes)
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(pmt.PMT_NIL, data_pmt))
                  
                  cursor += actual_len
                  self.seq_num = (self.seq_num + 1) % 256
                  time.sleep(self.interval)

              self.log(f"[File Source]	       File Done. Sending Flush...")
              for _ in range(self.flush_count):
                  if self.stop_thread: break
                  self.send_dummy_packet(data_capacity)

              self.log("[File Source]               Idle mode.")
              while not self.stop_thread:
                  time.sleep(1.0)
    file_path: '"C:/Users/PC/Desktop/Input.txt"'
    flush_count: '1'
    interval: '0.1'
    log_file: '"C:/Users/arosh/OneDrive/Desktop/Transmitter log.txt"'
    pdu_size: '64'
    preamble_count: '0'
  states: {state: disabled}
- name: epy_block_13
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class pdu_file_sink(gr.basic_block):
          def __init__(self, file_path='/home/user/output.txt', append_to_file=False):
              gr.basic_block.__init__(self,
                  name="PDU to Text File Sink",
                  in_sig=None,
                  out_sig=None)

              # INPUT: Validated Frames from Sequence Checker
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              self.file_path = file_path
              
              # Logic to handle file modes
              # If append is False, we delete the old file when the flowgraph starts
              if not append_to_file:
                  if os.path.exists(self.file_path):
                      try:
                          os.remove(self.file_path)
                          print(f"[File Sink] Deleted old file: {self.file_path}")
                      except Exception as e:
                          print(f"[File Sink Error] Could not clean file: {e}")

          def handle_msg(self, msg):
              try:
                  # 1. Extract Data
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  # Safety Check: Must have at least 3 bytes header + 1 byte data
                  if len(data_list) < 4:
                      return

                  # 2. Strip Header (SRC, DST, SN)
                  # The actual text starts at index 3
                  raw_payload = bytes(data_list[3:])
                  
                  # 3. Remove Zero Padding
                  # This removes any 0x00 bytes from the RIGHT side of the packet
                  clean_payload = raw_payload.rstrip(b'\x00')
                  
                  # 4. Decode to Text
                  # We use 'replace' to prevent crashing if a bit error slipped through
                  text_data = clean_payload.decode('utf-8', errors='replace')
                  
                  # 5. Write to File
                  # We open in 'a' (append) mode so we add to the end of the file
                  with open(self.file_path, 'a', encoding='utf-8') as f:
                      f.write(text_data)
                      # Note: We do NOT add a newline here, because the original file 
                      # might have been split in the middle of a sentence.
                      
                  # Optional: Print progress
                  # print(f"[File Sink] Wrote {len(text_data)} characters.")

              except Exception as e:
                  print(f"[File Sink Error] {e}")
    append_to_file: 'False'
    file_path: '"C:/Users/PC/Desktop/Output.txt"'
  states: {state: disabled}
- name: epy_block_13_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class pdu_file_sink(gr.basic_block):
          def __init__(self, file_path='/home/user/output.txt', append_to_file=False):
              gr.basic_block.__init__(self,
                  name="PDU to Text File Sink",
                  in_sig=None,
                  out_sig=None)

              # INPUT: Validated Frames from Sequence Checker
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              self.file_path = file_path
              
              # Logic to handle file modes
              # If append is False, we delete the old file when the flowgraph starts
              if not append_to_file:
                  if os.path.exists(self.file_path):
                      try:
                          os.remove(self.file_path)
                          print(f"[File Sink] Deleted old file: {self.file_path}")
                      except Exception as e:
                          print(f"[File Sink Error] Could not clean file: {e}")

          def handle_msg(self, msg):
              try:
                  # 1. Extract Data
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  # Safety Check: Must have at least 3 bytes header + 1 byte data
                  if len(data_list) < 4:
                      return

                  # 2. Strip Header (SRC, DST, SN)
                  # The actual text starts at index 3
                  raw_payload = bytes(data_list[3:])
                  
                  # 3. Remove Zero Padding
                  # This removes any 0x00 bytes from the RIGHT side of the packet
                  clean_payload = raw_payload.rstrip(b'\x00')
                  
                  # 4. Decode to Text
                  # We use 'replace' to prevent crashing if a bit error slipped through
                  text_data = clean_payload.decode('utf-8', errors='replace')
                  
                  # 5. Write to File
                  # We open in 'a' (append) mode so we add to the end of the file
                  with open(self.file_path, 'a', encoding='utf-8') as f:
                      f.write(text_data)
                      # Note: We do NOT add a newline here, because the original file 
                      # might have been split in the middle of a sentence.
                      
                  # Optional: Print progress
                  # print(f"[File Sink] Wrote {len(text_data)} characters.")

              except Exception as e:
                  print(f"[File Sink Error] {e}")
    append_to_file: 'False'
    file_path: '"C:/Users/PC/Desktop/Input.txt"'
  states: {state: disabled}
- name: fec_extended_tagged_decoder_2
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: cc_dec
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: fec_extended_tagged_encoder_0_1
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: cc_enc
    lentagname: '"packet_len"'
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX-SPECTRUM
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: Rx Bits
    label2: Tx Bits
    name: ''
    nconnections: '2'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      # Function to remove both front and back preambles and sequence from file
      import time
      import subprocess
      def remove_preamble(file_path):
          global content
          
          detect_sequence = b'sts'

          #with open(file_path, 'rb') as file:
              #content = file.read()

          start_index = content.find(detect_sequence)
          if start_index != -1:
              content = content[start_index + len(detect_sequence):]

          end_index = content.rfind(detect_sequence)
          if end_index != -1:
              content = content[:end_index]

      def tag():
           global content
           detected=False
           typs=[b'mp3',b'jpeg',b'mp4']
           
           while(not(detected)):
              with open('./rx.tmp', 'rb') as file:
                  content = file.read()
              time.sleep(1) 
              for tag in typs:
                  position= content.rfind(tag)
                  if position != -1:
                      remove_preamble('./rx.tmp')
                      if(tag==b'jpeg'):
                          with open("./out.jpg", 'wb') as file:
                              file.write(content)
                              detected=True
                              subprocess.run(["open","./out.jpg"])
                      if(tag==b'mp3'):
                          with open("./out.mp3", 'wb') as file:
                              file.write(content)
                              subprocess.run(["open","./out.mp3"])
                              detected=True
                      if(tag==b'ts'):
                          with open("./out.ts", 'wb') as file:
                              file.write(content)
                              subprocess.run(["open","./out.ts"])
                              detected=True
                      if(tag==b'mp4'):
                          with open("./out.mp4", 'wb') as file:
                              file.write(content)
                              subprocess.run(["open","./out.mp4"])
                              detected=True
                          print("detected")


      # Remove both front and back preambles and sequence from the output.tmp file
      tag()
    section: main_after_stop
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    gain: txgain
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: rxbw
    center_freq: freq
    gain: '30.0'
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: channel_rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: channel_rx
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_1, '0', qtgui_number_sink_0, '0']
- [blocks_char_to_float_1_1, '0', fec_extended_tagged_decoder_2, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_char_to_float_1, '0']
- [blocks_repack_bits_bb_0_0, '0', fec_extended_tagged_encoder_0_1, '0']
- [blocks_repack_bits_bb_0_0_1, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_repack_bits_bb_0_0_1, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_throttle2_1, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', digital_map_bb_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc_append_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_crc_check_0, fail, epy_block_0, pdu_in]
- [digital_crc_check_0, fail, pdu_pdu_to_tagged_stream_1_0, pdus]
- [digital_crc_check_0, ok, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_1_1, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [epy_block_1, pdu_out, epy_block_13_0, pdu_in]
- [epy_block_12, pdu_out, epy_block_1, pdu_in]
- [fec_extended_tagged_decoder_2, '0', blocks_repack_bits_bb_0, '0']
- [fec_extended_tagged_encoder_0_1, '0', blocks_repack_bits_bb_0_0_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_file_sink_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_append_0, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_0, '0', blocks_throttle2_1, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [virtual_source_2, '0', digital_correlate_access_code_xx_ts_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
