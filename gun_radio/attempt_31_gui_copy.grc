options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_8
    output_language: python
    title: pkt_8
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '1'
    padding: 'True'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 100e3
    stop: 6e9
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hdr_format_0
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.001'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.2'
  states: {state: disabled}
- name: phase_bw
  id: variable
  parameters:
    value: '0.05'
  states: {state: disabled}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {state: disabled}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 750e3
  states: {}
- name: sample_rate_blade
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: tuning_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Tuning
    start: '-70e3'
    step: '50'
    stop: 70e3
    value: '-21e3'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_1
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_2
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_1_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: '0'
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: channels_channel_model_0_1
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {state: disabled}
- name: digital_crc32_bb_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_crc_check_1
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {state: disabled}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {state: disabled}
- name: digital_linear_equalizer_0_1
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {state: disabled}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {state: disabled}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {state: disabled}
- name: digital_protocol_formatter_async_0_1
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class crc_fail_logger(gr.basic_block):
          def __init__(self, log_file=''):
              gr.basic_block.__init__(self,
                  name="CRC Fail Logger",
                  in_sig=None,
                  out_sig=None)

              # INPUT: Connect this to the 'fail' port of the CRC Check block
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              
              self.fail_count = 0
              
              # LOGGING SETUP
              self.log_file_path = log_file
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- CRC FAILURE LOG START ---\n")
                  except: pass

          def log(self, message):
              """Helper function to Print AND Write to file"""
              print(message)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          timestamp = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{timestamp}] {message}\n")
                  except: pass

          def handle_msg(self, msg):
              try:
                  self.fail_count += 1
                  
                  # Extract the length of the bad packet just for info
                  payload = pmt.cdr(msg)
                  data_len = len(pmt.u8vector_elements(payload))
                  
                  self.log(f"[CRC FAIL] Corrupted Packet Dropped! (Size: {data_len} bytes | Total Fails: {self.fail_count})")
                  
              except Exception as e:
                  self.log(f"[CRC Log Error] {e}")
    log_file: '"C:/Users/PC/Desktop/Receiver log.txt"'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import threading
      import os

      class pdu_storage_buffer(gr.basic_block):
          def __init__(self, timeout=1.0, max_retries=5, log_file=''):
              gr.basic_block.__init__(self,
                  name="PDU Storage",
                  in_sig=None,
                  out_sig=None)

              # PORTS
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_incoming_pdu)

              self.message_port_register_in(pmt.intern("request_in"))
              self.set_msg_handler(pmt.intern("request_in"), self.handle_request)

              self.message_port_register_out(pmt.intern("pdu_out"))

              # STORAGE & STATE
              self.pdu_storage = {}
              self.in_preamble_phase = True
              
              # TIMEOUT PARAMETERS
              self.timeout = timeout
              self.max_retries = max_retries
              
              # TIMEOUT STATE
              self.current_seq_waiting = 0 
              self.retry_count = 0
              self.last_tx_time = time.time()
              
              # LOGGING SETUP
              self.log_file_path = log_file
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- ARQ STORAGE LOG START ---\n")
                  except: pass
              
              # THREADING
              self.stop_thread = False
              self.thread = threading.Thread(target=self.timer_loop)
              self.thread.daemon = True

          def start(self):
              self.stop_thread = False
              self.thread.start()
              return True

          def stop(self):
              self.stop_thread = True
              self.thread.join()
              return True

          def log(self, message):
              print(message)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          timestamp = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{timestamp}] {message}\n")
                  except: pass

          def handle_incoming_pdu(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  data = pmt.u8vector_elements(payload)
                  if len(data) < 1: return
                  seq_num = data[0]
                  
                  # Store PDU
                  self.pdu_storage[seq_num] = msg

                  # PREAMBLE LOGIC
                  if self.in_preamble_phase:
                      self.log(f"[PDU Storage Buffer]        Preamble/Init #{seq_num} sending.")
                      self.message_port_pub(pmt.intern("pdu_out"), msg)
                      
                      if seq_num == 0:
                          self.in_preamble_phase = False
                          self.current_seq_waiting = 0
                          self.reset_timer()

              except Exception as e:
                  self.log(f"[PDU Storage Error] Store: {e}")

          def handle_request(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  data = pmt.u8vector_elements(payload)
                  if len(data) < 1: return
                  
                  req_seq = data[0]

                  # --- FIX: GHOST ACK PROTECTION ---
                  diff = (req_seq - self.current_seq_waiting + 256) % 256
                  
                  if diff > 128:
                      self.log(f"[PDU Storage Ignore]      Ignoring old request for #{req_seq} (I am at #{self.current_seq_waiting})")
                      return
                  # --------------------------------

                  # UPDATE STATE
                  if req_seq != self.current_seq_waiting:
                      self.log(f"[PDU Storage Buffer]        ACK received! Moving target to #{req_seq}")
                      self.current_seq_waiting = req_seq
                      self.reset_timer() 
                      
                      # --- COMPLETION CHECK ---
                      # If we moved to a sequence number we don't have yet, 
                      # it means we finished everything currently in the buffer.
                      if self.current_seq_waiting not in self.pdu_storage:
                          self.log(f"[PDU Storage Info] All packets sent & ACKed. Transmission Complete.")

                  # SEND IMMEDIATELY
                  if req_seq in self.pdu_storage:
                      self.send_pdu(req_seq)
                  else:
                      pass

              except Exception as e:
                  self.log(f"[PDU Storage Error] Request: {e}")

          def send_pdu(self, seq_num):
              if seq_num in self.pdu_storage:
                  self.message_port_pub(pmt.intern("pdu_out"), self.pdu_storage[seq_num])
                  self.last_tx_time = time.time() 

          def reset_timer(self):
              self.retry_count = 0
              self.last_tx_time = time.time()

          def timer_loop(self):
              time.sleep(2.0)
              
              while not self.stop_thread:
                  time.sleep(0.1) 
                  
                  if self.in_preamble_phase:
                      continue

                  now = time.time()
                  if (now - self.last_tx_time) > self.timeout:
                      
                      if self.retry_count < self.max_retries:
                          if self.current_seq_waiting in self.pdu_storage:
                              self.log(f"[PDU Storage Timeout]       Resending #{self.current_seq_waiting} (Attempt {self.retry_count + 1}/{self.max_retries})")
                              self.send_pdu(self.current_seq_waiting)
                              self.retry_count += 1
                          else:
                              self.last_tx_time = time.time()
                              
                      else:
                          # MAX RETRIES REACHED -> SKIP
                          self.log(f"[PDU Storage Skip]          Max retries failed for #{self.current_seq_waiting}. Skipping.")
                          
                          # Move to next sequence number
                          self.current_seq_waiting = (self.current_seq_waiting + 1) % 256
                          
                          # Reset retries for the NEW target
                          self.retry_count = 0
                          
                          # Send immediate update
                          if self.current_seq_waiting in self.pdu_storage:
                              self.log(f"[PDU Storage Skip]          Sending new target #{self.current_seq_waiting}")
                              self.send_pdu(self.current_seq_waiting)
                          else:
                              self.last_tx_time = time.time()
                              # --- COMPLETION CHECK (ON SKIP) ---
                              self.log(f"[PDU Storage Info] Skipped to end. Transmission Complete (Buffer Empty).")
    log_file: '"C:/Users/PC/Desktop/Transmitter log.txt"'
    max_retries: '2'
    timeout: '1'
  states: {}
- name: epy_block_10
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class dest_addr_check(gr.basic_block):
          def __init__(self, my_address=20):
              gr.basic_block.__init__(self,
                  name="Destination Address Filter",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Input (From CRC Block)
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # 2. Register Output (To ARQ/Decoder Block)
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 3. Store My Address
              self.my_addr = my_address

          def handle_msg(self, msg):
              try:
                  # Extract data from PDU
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  # Safety Check: Packet must be at least 2 bytes (SRC + DST)
                  if len(data_list) < 2:
                      return

                  # --- ADDRESS LOGIC ---
                  # Based on your structure: Byte 0 = SRC, Byte 1 = DST
                  packet_dst = data_list[1] 

                  # Compare
                  if packet_dst == self.my_addr:
                      # MATCH: Valid packet for me.
                      # Pass the WHOLE frame (header + payload) to the next block.
                      self.message_port_pub(pmt.intern("pdu_out"), msg)
                  else:
                      # MISMATCH: Packet is for someone else.
                      # Drop it silently (or print for debug)
                      # print(f"Dropped packet for User #{packet_dst}")
                      pass

              except Exception as e:
                  print(f"[Addr Check Error] {e}")
    my_address: '20'
  states: {state: disabled}
- name: epy_block_10_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class dest_addr_check(gr.basic_block):
          def __init__(self, my_address=20):
              gr.basic_block.__init__(self,
                  name="Destination Address Filter",
                  in_sig=None,
                  out_sig=None)

              # 1. Register Input (From CRC Block)
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # 2. Register Output (To ARQ/Decoder Block)
              self.message_port_register_out(pmt.intern("pdu_out"))

              # 3. Store My Address
              self.my_addr = my_address

          def handle_msg(self, msg):
              try:
                  # Extract data from PDU
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  # Safety Check: Packet must be at least 2 bytes (SRC + DST)
                  if len(data_list) < 2:
                      return

                  # --- ADDRESS LOGIC ---
                  # Based on your structure: Byte 0 = SRC, Byte 1 = DST
                  packet_dst = data_list[0] 

                  # Compare
                  if packet_dst == self.my_addr:
                      # MATCH: Valid packet for me.
                      # Pass the WHOLE frame (header + payload) to the next block.
                      self.message_port_pub(pmt.intern("pdu_out"), msg)
                  else:
                      # MISMATCH: Packet is for someone else.
                      # Drop it silently (or print for debug)
                      # print(f"Dropped packet for User #{packet_dst}")
                      pass

              except Exception as e:
                  print(f"[Addr Check Error] {e}")
    my_address: '10'
  states: {state: disabled}
- name: epy_block_11
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class sequence_checker(gr.basic_block):
          def __init__(self, initial_rn=0, log_file=''):
              gr.basic_block.__init__(self,
                  name="Sequence Check",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("frame_out"))
              self.message_port_register_out(pmt.intern("rn_out"))

              self.current_rn = initial_rn
              self.log_file_path = log_file
              
              # Init Log
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- COMMUNICATION START ---\n")
                  except: pass

          def log(self, msg):
              print(msg)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          t = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{t}] {msg}\n")
                  except: pass

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  if len(data_list) < 3: return

                  incoming_src = data_list[0]
                  incoming_dst = data_list[1]
                  incoming_sn  = data_list[2]

                  # --- SKIP LOGIC START ---
                  
                  # Calculate the "Distance" forward. 
                  diff = (incoming_sn - self.current_rn + 256) % 256
                  
                  if diff == 0:
                      # EXACT MATCH
                      self.message_port_pub(pmt.intern("frame_out"), msg)
                      self.current_rn = (self.current_rn + 1) % 256
                      self.log(f"[Sqnc Checker Match]        Got #{incoming_sn}. Next: #{self.current_rn}")
                      
                  elif diff < 10: 
                      # SMALL SKIP DETECTED (e.g., missed 1 or 2 packets)
                      self.log(f"[Sqnc Checker Skip]         Wanted #{self.current_rn}, but got #{incoming_sn}. Jumping forward.")
                      
                      # Output the packet we just got
                      self.message_port_pub(pmt.intern("frame_out"), msg)
                      
                      # Update expectation to the ONE AFTER this new packet
                      self.current_rn = (incoming_sn + 1) % 256
                      
                  else:
                      # LARGE GAP or OLD PACKET
                      self.log(f"[Sqnc Checker Drop]         Got #{incoming_sn} (Expected #{self.current_rn}). Ignoring.")

                  # ALWAYS send ACK for what we want NEXT
                  self.send_ack_packet(incoming_src, incoming_dst, self.current_rn)

              except Exception as e:
                  self.log(f"[Sqnc Checker Error] {e}")

          def send_ack_packet(self, target_dst, my_src, rn_val):
              try:
                  ack_payload = [target_dst, my_src, rn_val]
                  out_vec = pmt.init_u8vector(len(ack_payload), ack_payload)
                  out_msg = pmt.cons(pmt.PMT_NIL, out_vec)
                  self.message_port_pub(pmt.intern("rn_out"), out_msg)
              except Exception as e:
                  self.log(f"[Sqnc Checker ACK Error] {e}")
    initial_rn: '0'
    log_file: '"C:/Users/PC/Desktop/Receiver log.txt"'
  states: {state: disabled}
- name: epy_block_12
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import threading

      class pdu_file_source(gr.basic_block):
          def __init__(self, file_path='/home/user/test.txt', pdu_size=50, interval=1.0, flush_count=10, preamble_count=20, log_file=''):
              gr.basic_block.__init__(self,
                  name="File Source",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern("pdu_out"))

              self.file_path = file_path
              self.pdu_size = pdu_size
              self.interval = interval
              self.flush_count = flush_count
              self.preamble_count = preamble_count
              self.log_file_path = log_file
              
              self.seq_num = 0
              self.stop_thread = False
              self.thread = threading.Thread(target=self.run)
              self.thread.daemon = True

              # Init Log
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- TX SOURCE LOG START ---\n")
                  except: pass

          def log(self, msg):
              print(msg)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          t = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{t}] {msg}\n")
                  except: pass

          def start(self):
              self.stop_thread = False
              self.thread.start()
              return True

          def stop(self):
              self.stop_thread = True
              self.thread.join()
              return True

          def send_dummy_packet(self, capacity):
              dummy_payload = [self.seq_num] + ([0] * capacity)
              data_pmt = pmt.init_u8vector(len(dummy_payload), dummy_payload)
              pdu_msg = pmt.cons(pmt.PMT_NIL, data_pmt)
              self.message_port_pub(pmt.intern("pdu_out"), pdu_msg)
              self.seq_num = (self.seq_num + 1) % 256
              time.sleep(self.interval)

          def run(self):
              time.sleep(2.0) 
              data_capacity = self.pdu_size - 1

              self.log(f"[File Source]	       Sending {self.preamble_count} Preamble packets...")
              self.seq_num = (256 - self.preamble_count) % 256
              
              for _ in range(self.preamble_count):
                  if self.stop_thread: break
                  self.send_dummy_packet(data_capacity)

              # --- PART 1: SEND FILE ---
              try:
                  with open(self.file_path, 'rb') as f:
                      file_data = f.read()
              except Exception as e:
                  self.log(f"[File Source Error] {e}")
                  return

              total_len = len(file_data)
              cursor = 0
              self.log(f"[File Source]	       Starting File Transmission (Packet #{self.seq_num})...")

              while not self.stop_thread and cursor < total_len:
                  end_pointer = min(cursor + data_capacity, total_len)
                  data_chunk = file_data[cursor : end_pointer]
                  actual_len = len(data_chunk)
                  padding_list = [0] * (data_capacity - actual_len)

                  payload_bytes = [self.seq_num] + list(data_chunk) + padding_list
                  data_pmt = pmt.init_u8vector(len(payload_bytes), payload_bytes)
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(pmt.PMT_NIL, data_pmt))
                  
                  cursor += actual_len
                  self.seq_num = (self.seq_num + 1) % 256
                  time.sleep(self.interval)

              self.log(f"[File Source]	       File Done. Sending Flush...")
              for _ in range(self.flush_count):
                  if self.stop_thread: break
                  self.send_dummy_packet(data_capacity)

              self.log("[File Source]               Idle mode.")
              while not self.stop_thread:
                  time.sleep(1.0)
    file_path: '"C:/Users/PC/Desktop/Input.txt"'
    flush_count: '1'
    interval: '0.1'
    log_file: '"C:/Users/PC/Desktop/Transmitter log.txt"'
    pdu_size: '1024'
    preamble_count: '0'
  states: {state: disabled}
- name: epy_block_13
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class pdu_file_sink(gr.basic_block):
          def __init__(self, file_path='/home/user/output.txt', append_to_file=False):
              gr.basic_block.__init__(self,
                  name="PDU to Text File Sink",
                  in_sig=None,
                  out_sig=None)

              # INPUT: Validated Frames from Sequence Checker
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              self.file_path = file_path
              
              # Logic to handle file modes
              # If append is False, we delete the old file when the flowgraph starts
              if not append_to_file:
                  if os.path.exists(self.file_path):
                      try:
                          os.remove(self.file_path)
                          print(f"[File Sink] Deleted old file: {self.file_path}")
                      except Exception as e:
                          print(f"[File Sink Error] Could not clean file: {e}")

          def handle_msg(self, msg):
              try:
                  # 1. Extract Data
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  # Safety Check: Must have at least 3 bytes header + 1 byte data
                  if len(data_list) < 4:
                      return

                  # 2. Strip Header (SRC, DST, SN)
                  # The actual text starts at index 3
                  raw_payload = bytes(data_list[3:])
                  
                  # 3. Remove Zero Padding
                  # This removes any 0x00 bytes from the RIGHT side of the packet
                  clean_payload = raw_payload.rstrip(b'\x00')
                  
                  # 4. Decode to Text
                  # We use 'replace' to prevent crashing if a bit error slipped through
                  text_data = clean_payload.decode('utf-8', errors='replace')
                  
                  # 5. Write to File
                  # We open in 'a' (append) mode so we add to the end of the file
                  with open(self.file_path, 'a', encoding='utf-8') as f:
                      f.write(text_data)
                      # Note: We do NOT add a newline here, because the original file 
                      # might have been split in the middle of a sentence.
                      
                  # Optional: Print progress
                  # print(f"[File Sink] Wrote {len(text_data)} characters.")

              except Exception as e:
                  print(f"[File Sink Error] {e}")
    append_to_file: 'False'
    file_path: '"C:/Users/PC/Desktop/Output.txt"'
  states: {}
- name: epy_block_13_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class pdu_file_sink(gr.basic_block):
          def __init__(self, file_path='/home/user/output.txt', append_to_file=False):
              gr.basic_block.__init__(self,
                  name="PDU to Text File Sink",
                  in_sig=None,
                  out_sig=None)

              # INPUT: Validated Frames from Sequence Checker
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              self.file_path = file_path
              
              # Logic to handle file modes
              # If append is False, we delete the old file when the flowgraph starts
              if not append_to_file:
                  if os.path.exists(self.file_path):
                      try:
                          os.remove(self.file_path)
                          print(f"[File Sink] Deleted old file: {self.file_path}")
                      except Exception as e:
                          print(f"[File Sink Error] Could not clean file: {e}")

          def handle_msg(self, msg):
              try:
                  # 1. Extract Data
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  # Safety Check: Must have at least 3 bytes header + 1 byte data
                  if len(data_list) < 4:
                      return

                  # 2. Strip Header (SRC, DST, SN)
                  # The actual text starts at index 3
                  raw_payload = bytes(data_list[3:])
                  
                  # 3. Remove Zero Padding
                  # This removes any 0x00 bytes from the RIGHT side of the packet
                  clean_payload = raw_payload.rstrip(b'\x00')
                  
                  # 4. Decode to Text
                  # We use 'replace' to prevent crashing if a bit error slipped through
                  text_data = clean_payload.decode('utf-8', errors='replace')
                  
                  # 5. Write to File
                  # We open in 'a' (append) mode so we add to the end of the file
                  with open(self.file_path, 'a', encoding='utf-8') as f:
                      f.write(text_data)
                      # Note: We do NOT add a newline here, because the original file 
                      # might have been split in the middle of a sentence.
                      
                  # Optional: Print progress
                  # print(f"[File Sink] Wrote {len(text_data)} characters.")

              except Exception as e:
                  print(f"[File Sink Error] {e}")
    append_to_file: 'False'
    file_path: '"C:/Users/PC/Desktop/Output2.txt"'
  states: {}
- name: epy_block_14_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class rn_debugger(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="RN Debug Print",
                  in_sig=None,
                  out_sig=None)

              # Input Port: Connect to 'rn_out' of ACK Decoder
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  # 1. Extract Data
                  # The ACK Decoder sends a clean PDU with just [RN]
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  if len(data_list) < 1:
                      return

                  # 2. Get the Number
                  rn_val = data_list[0]

                  # 3. Print to Console
                  print(f"[TX-SIDE DEBUG] Receiver is asking for Packet #{rn_val}")

              except Exception as e:
                  print(f"[RN Debug Error] {e}")
  states: {state: disabled}
- name: epy_block_15
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class ack_decoder(gr.basic_block):
          def __init__(self, log_file=''):
              gr.basic_block.__init__(self,
                  name="ACK Decoder",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("rn_out"))
              
              self.log_file_path = log_file
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'w') as f:
                          f.write("--- ACK DECODER LOG START ---\n")
                  except: 
                      pass

          def log(self, msg):
              print(msg)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          t = time.strftime("%H:%M:%S", time.localtime())
                          f.write(f"[{t}] {msg}\n")
                  except: 
                      pass

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                 
                  if len(data_list) < 3:
                      return

                  rn_val = data_list[-1]
                  
                  out_payload = [rn_val]
                  out_vec = pmt.init_u8vector(1, out_payload)
                  out_msg = pmt.cons(pmt.PMT_NIL, out_vec)
                  
                  self.message_port_pub(pmt.intern("rn_out"), out_msg)
                  
                  self.log(f"[ACK Decoder ACK] Received Request for #{rn_val}")

              except Exception as e:
                  self.log(f"[ACK Error] {e}")
    log_file: '"C:/Users/PC/Desktop/Transmitter log.txt"'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES
      from Crypto.Util import Counter

      class aes_encrypt_pdu(gr.basic_block):
          def __init__(self, key_str='1234567890123456', log_file=''):
              gr.basic_block.__init__(self,
                  name="AES Encrypt PDU",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

              # AES CONFIG
              # Key must be exactly 16, 24, or 32 bytes
              self.key = key_str.encode('utf-8')
              
              # LOGGING
              self.log_file_path = log_file

          def log(self, msg):
              print(msg)
              if self.log_file_path != '':
                  try:
                      with open(self.log_file_path, 'a') as f:
                          f.write(f"{msg}\n")
                  except: pass

          def handle_msg(self, msg):
              try:
                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  if len(data_list) < 2: return

                  # 1. Separate Seq Num from Data
                  # Byte 0 is Sequence Number. We DO NOT encrypt this so ARQ still works.
                  seq_num = data_list[0]
                  raw_data = bytes(data_list[1:])
                  
                  # 2. Create AES Cipher
                  # We use the SeqNum to create a unique counter for every packet.
                  # This is critical for security (prevents "Two Time Pad" attack).
                  # initial_value must be integer.
                  ctr = Counter.new(128, initial_value=seq_num + 1) 
                  cipher = AES.new(self.key, AES.MODE_CTR, counter=ctr)
                  
                  # 3. Encrypt Payload
                  encrypted_bytes = cipher.encrypt(raw_data)
                  
                  # 4. Rebuild PDU: [Seq Num] + [Encrypted Data]
                  out_list = [seq_num] + list(encrypted_bytes)
                  out_vec = pmt.init_u8vector(len(out_list), out_list)
                  out_msg = pmt.cons(pmt.PMT_NIL, out_vec)
                  
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)

              except Exception as e:
                  self.log(f"[AES Encrypt Error] {e}")
    key_str: '''1234567890123456'''
    log_file: '"C:/Users/arosh/OneDrive/Desktop/Transmitter log.txt"'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class aes_decrypt_pdu(gr.basic_block):
          def __init__(self, key_str='1234567890123456'):
              gr.basic_block.__init__(self,
                  name="AES Decrypt PDU (Header Aware)",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

              # Robust Fix: Convert to string first to avoid GRC integer errors
              self.key = str(key_str).encode('utf-8')

          def handle_msg(self, msg):
              try:
                  # LAZY IMPORT
                  from Crypto.Cipher import AES
                  from Crypto.Util import Counter

                  payload_pmt = pmt.cdr(msg)
                  data_list = pmt.u8vector_elements(payload_pmt)
                  
                  # Safety Check: Must have [SRC, DST, SEQ] + Data
                  if len(data_list) < 3: return

                  # --- HEADER PARSING (The Fix) ---
                  # 1. Extract Headers (Keep them safe to send out later)
                  src_addr = data_list[0]
                  dst_addr = data_list[1]
                  
                  # 2. Extract Sequence Number (It is the 3rd byte, Index 2)
                  seq_num = data_list[2]
                  
                  # 3. Extract Encrypted Data (Everything after the first 3 bytes)
                  encrypted_data = bytes(data_list[3:])
                  # ----------------------

                  # 4. Setup Cipher (Must match Transmitter logic)
                  # Use seq_num to sync the counter
                  ctr = Counter.new(128, initial_value=seq_num + 1)
                  cipher = AES.new(self.key, AES.MODE_CTR, counter=ctr)
                  
                  # 5. Decrypt
                  decrypted_bytes = cipher.decrypt(encrypted_data)
                  
                  # 6. Rebuild PDU: [SRC, DST, SEQ, Decrypted Data]
                  # We include headers so your File Sink can strip them correctly
                  out_list = [src_addr, dst_addr, seq_num] + list(decrypted_bytes)
                  
                  out_vec = pmt.init_u8vector(len(out_list), out_list)
                  out_msg = pmt.cons(pmt.PMT_NIL, out_vec)
                  
                  self.message_port_pub(pmt.intern("pdu_out"), out_msg)

              except Exception as e:
                  print(f"[AES Decrypt Error] {e}")
    key_str: '''1234567890123456'''
  states: {state: disabled}
- name: epy_block_9
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class add_src_dst(gr.basic_block):
          def __init__(self, src_addr=10, dst_addr=20):
              gr.basic_block.__init__(self,
                  name="Add SRC/DST Addresses",
                  in_sig=None,
                  out_sig=None)

              # Input Port (From Storage Buffer)
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)

              # Output Port (To CRC or Protocol Formatter)
              self.message_port_register_out(pmt.intern("pdu_out"))

              # Store addresses (Ensure they are between 0-255)
              self.src = src_addr
              self.dst = dst_addr

          def handle_msg(self, msg):
              try:
                  # 1. Extract the existing PDU data (Seq Num + Payload)
                  # msg is a pair: (metadata, data_vector)
                  payload_pmt = pmt.cdr(msg)
                  payload_list = pmt.u8vector_elements(payload_pmt)
                  
                  # 2. Create the New Header
                  # We prepend the addresses to the existing data
                  # Structure becomes: [SRC] [DST] [SEQ] [DATA...]
                  header_bytes = [self.src, self.dst]
                  
                  # Combine them
                  new_payload = header_bytes + list(payload_list)
                  
                  # 3. Repack into a PMT PDU
                  new_vec = pmt.init_u8vector(len(new_payload), new_payload)
                  new_msg = pmt.cons(pmt.PMT_NIL, new_vec)
                  
                  # 4. Send to next block
                  self.message_port_pub(pmt.intern("pdu_out"), new_msg)
                  
              except Exception as e:
                  print(f"[Address Adder Error] {e}")
    dst_addr: '20'
    src_addr: '10'
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1500'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '100'
    port: '53001'
    type: TCP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1500'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '100'
    port: '53002'
    type: UDP_SERVER
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: After Liner Equilizer
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: Modulated
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: ACK
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    name: After Symbol Sync
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_1_0
  id: qtgui_const_sink_x
  parameters:
    name: After Costas Loop
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Transmitted_1
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Transmitted_2
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Transmitted_1
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    dev_args: '0'
    gain: '40'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '9000'
    center_freq: freq
    dev_args: '0'
    gain: '40'
    samp_rate: sample_rate_blade
    type: fc32
  states: {state: disabled}

connections:
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_pack_k_bits_bb_0_1, '0', digital_correlate_access_code_xx_ts_0_1, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_1, '0', digital_crc32_bb_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_1, '0', blocks_throttle2_0_0, '0']
- [blocks_repack_bits_bb_1_0_2, '0', blocks_throttle2_0_2, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', blocks_repack_bits_bb_1_0_1, '0']
- [blocks_tagged_stream_mux_0_1, '0', digital_crc32_bb_0_1, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0_1, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_1_0, '0', channels_channel_model_0_0, '0']
- [blocks_throttle2_0_1_1, '0', channels_channel_model_0_1, '0']
- [blocks_throttle2_0_2, '0', digital_constellation_modulator_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', blocks_pack_k_bits_bb_0_1, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [channels_channel_model_0_1, '0', digital_symbol_sync_xx_0_1, '0']
- [channels_channel_model_0_1, '0', qtgui_freq_sink_x_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_1_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_throttle2_0_1_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_1, '0', blocks_repack_bits_bb_1_0_0_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0_1_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0_1, '0', digital_constellation_decoder_cb_0_1, '0']
- [digital_crc32_bb_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0_1, '0']
- [digital_crc32_bb_0_1, '0', blocks_repack_bits_bb_1_0_2, '0']
- [digital_crc_append_0_0, out, digital_protocol_formatter_async_0_0, in]
- [digital_crc_check_0, fail, epy_block_0, pdu_in]
- [digital_crc_check_0, fail, epy_block_13_0, pdu_in]
- [digital_crc_check_0, ok, epy_block_10, pdu_in]
- [digital_crc_check_0, ok, network_socket_pdu_1, pdus]
- [digital_crc_check_0_0, ok, epy_block_10_0, pdu_in]
- [digital_crc_check_1, fail, epy_block_13_0, pdu_in]
- [digital_crc_check_1, fail, network_socket_pdu_1, pdus]
- [digital_crc_check_1, ok, epy_block_13, pdu_in]
- [digital_crc_check_1, ok, network_socket_pdu_1, pdus]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_diff_decoder_bb_0_1, '0', digital_map_bb_0_1, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_linear_equalizer_0_1, '0', digital_costas_loop_cc_0_0_1, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_1, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_protocol_formatter_async_0_1, header, pdu_pdu_to_tagged_stream_0_2, pdus]
- [digital_protocol_formatter_async_0_1, payload, pdu_pdu_to_tagged_stream_0_0_1, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_1, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_1, '0', digital_linear_equalizer_0_1, '0']
- [epy_block_1, pdu_out, digital_protocol_formatter_async_0, in]
- [epy_block_1, pdu_out, epy_block_9, pdu_in]
- [epy_block_10, pdu_out, epy_block_11, pdu_in]
- [epy_block_10_0, pdu_out, epy_block_15, pdu_in]
- [epy_block_11, frame_out, epy_block_13, pdu_in]
- [epy_block_11, frame_out, epy_block_3, pdu_in]
- [epy_block_11, rn_out, digital_crc_append_0_0, in]
- [epy_block_12, pdu_out, epy_block_2, pdu_in]
- [epy_block_15, rn_out, epy_block_1, request_in]
- [epy_block_15, rn_out, epy_block_14_0, pdu_in]
- [epy_block_2, pdu_out, epy_block_1, pdu_in]
- [epy_block_3, pdu_out, epy_block_13, pdu_in]
- [network_socket_pdu_0, pdus, epy_block_1, pdu_in]
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_1, pdus]
- [network_socket_pdu_0_0, pdus, digital_protocol_formatter_async_0_1, in]
- [network_socket_pdu_0_0, pdus, epy_block_1, pdu_in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_1, '0', blocks_tagged_stream_mux_0_1, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_2, '0', blocks_tagged_stream_mux_0_1, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_1, in]
- [pdu_tagged_stream_to_pdu_0_0_0, pdus, digital_crc_check_0_0, in]
- [pdu_tagged_stream_to_pdu_0_0_1, pdus, network_socket_pdu_1_0, pdus]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
