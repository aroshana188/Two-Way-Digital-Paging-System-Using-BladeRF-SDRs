options:
  parameters:
    author: Geeth Sathsara
    generate_options: qt_gui
    id: CommunicationSystem
    output_language: python
    title: CDP
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bw
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: delay
  id: variable
  parameters:
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {state: disabled}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {state: disabled}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {state: disabled}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from PyQt5 import QtWidgets, QtCore
      from collections import deque
      from datetime import datetime

      ADDRESS_MAP = {"userA": 0x00, "userB": 0x01, "userC": 0x02}
      NAME_MAP = {v: k for k, v in ADDRESS_MAP.items()}


      class gui_io(gr.basic_block):
          """
          GUI Chat Window.
          """
          def __init__(self, my_name="userA"):
              gr.basic_block.__init__(self, name="Messages App", in_sig=[], out_sig=[])
              self.my_name = my_name
              self.tx_queue = deque()

              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_rx)
              self.message_port_register_out(pmt.intern("out"))

              self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication([])
              self.window = ChatWindow(self, self.tx_queue)
              self.window.show()

              self.timer = QtCore.QTimer()
              self.timer.timeout.connect(self.process_tx)
              self.timer.start(50)

          def handle_rx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  data = list(pmt.u8vector_elements(pmt.cdr(msg_pmt)))
                  if len(data) < 3:
                      return
                  emergency = bool(data[0])
                  src_addr = data[1]
                  dst_addr = data[2]
                  msg_bytes = data[3:]
                  msg_str = bytes(msg_bytes).decode('utf-8', errors='ignore')
                  src_name = NAME_MAP.get(src_addr, f"Unknown({src_addr})")
                  dst_name = NAME_MAP.get(dst_addr, f"Unknown({dst_addr})")

                  self.window.new_message_signal.emit(msg_str, emergency, src_name, dst_name)

          def process_tx(self):
              while self.tx_queue:
                  msg, emergency, src, dst = self.tx_queue.popleft()
                  dst_addr = ADDRESS_MAP.get(dst, 0xFF)
                  data_list = [int(emergency), ADDRESS_MAP[self.my_name], dst_addr] + list(msg.encode('utf-8'))
                  out_pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(data_list), data_list))
                  self.message_port_pub(pmt.intern("out"), out_pdu)

          def stop(self):
              self.window.close()
              return True


      class ChatWindow(QtWidgets.QWidget):
          new_message_signal = QtCore.pyqtSignal(str, bool, str, str)

          def __init__(self, block, tx_queue):
              super().__init__()
              self.block = block
              self.tx_queue = tx_queue

              self.new_message_signal.connect(self.add_message_bubble)

              self.setWindowTitle(f"Messages: {self.block.my_name}")
              self.setStyleSheet("background-color: #e6f0f8;")
              self.resize(700, 500)

              self.layout = QtWidgets.QVBoxLayout(self)
              self.layout.setContentsMargins(15, 15, 15, 15)
              self.layout.setSpacing(10)

              self.scroll_area = QtWidgets.QScrollArea()
              self.scroll_area.setWidgetResizable(True)
              self.scroll_area.setStyleSheet("""
                  QScrollArea { 
                      border: 1px solid #c0c0c0; 
                      border-radius: 8px; 
                      background-color: #ffffff;
                  }
              """)
              self.chat_container = QtWidgets.QWidget()
              self.chat_container.setStyleSheet("background-color: #ffffff; border-radius: 8px;")
              self.chat_layout = QtWidgets.QVBoxLayout(self.chat_container)
              self.chat_layout.setContentsMargins(10, 10, 10, 10)
              self.chat_layout.setSpacing(8)
              self.chat_layout.addStretch(1)
              self.scroll_area.setWidget(self.chat_container)
              self.layout.addWidget(self.scroll_area)

              input_group = QtWidgets.QFrame()
              input_group.setStyleSheet("""
                  QFrame { 
                      background-color: #f0f4f8; 
                      border-radius: 8px; 
                  }
              """)
              input_layout = QtWidgets.QHBoxLayout(input_group)
              input_layout.setContentsMargins(8, 5, 8, 5)
              input_layout.setSpacing(5)

              self.input_line = QtWidgets.QLineEdit()
              self.input_line.setPlaceholderText("Text Message . ")
              self.input_line.setStyleSheet("padding: 5px; font-size: 12pt;")
              input_layout.addWidget(self.input_line, 3)

              self.dst_line = QtWidgets.QLineEdit()
              self.dst_line.setPlaceholderText("To")
              self.dst_line.setFixedWidth(120)
              self.dst_line.setStyleSheet("padding: 5px; font-size: 12pt;")
              input_layout.addWidget(self.dst_line, 1)

              self.emergency_checkbox = QtWidgets.QCheckBox("Emergency")
              self.emergency_checkbox.setStyleSheet("font-size: 11pt; padding: 3px;")
              input_layout.addWidget(self.emergency_checkbox)

              self.send_button = QtWidgets.QPushButton("Send")
              self.send_button.setStyleSheet("""
                  QPushButton { 
                      background-color: #4a90e2; 
                      color: white; 
                      font-size: 12pt; 
                      padding: 6px 12px; 
                      border-radius: 6px; 
                  }
                  QPushButton:hover { background-color: #357ab7; }
              """)
              input_layout.addWidget(self.send_button)

              self.layout.addWidget(input_group)

              self.send_button.clicked.connect(self.queue_message)
              self.input_line.returnPressed.connect(self.queue_message)

          def queue_message(self):
              msg = self.input_line.text()
              dst_name = self.dst_line.text()
              if msg and dst_name in ADDRESS_MAP:
                  emergency_flag = self.emergency_checkbox.isChecked()
                  self.tx_queue.append((msg, emergency_flag, self.block.my_name, dst_name))
                  self.new_message_signal.emit(msg, emergency_flag, self.block.my_name, dst_name)
                  self.input_line.clear()
                  self.dst_line.clear()
                  self.emergency_checkbox.setChecked(False)

          def add_message_bubble(self, msg, emergency, src, dst):
              bubble = QtWidgets.QFrame()
              bubble.setMaximumWidth(400)
              bubble_layout = QtWidgets.QVBoxLayout(bubble)
              bubble_layout.setContentsMargins(12, 8, 12, 8)
              bubble_layout.setSpacing(2)

              msg_label = QtWidgets.QLabel(msg)
              msg_label.setWordWrap(True)
              msg_label.setStyleSheet("font-size: 12pt;")
              bubble_layout.addWidget(msg_label)

              other_name = dst if src == self.block.my_name else src
              timestamp = datetime.now().strftime("%H:%M:%S")
              footer_label = QtWidgets.QLabel(f"{other_name} | {timestamp}")
              footer_label.setStyleSheet("font-size: 8pt; color: #555555;")
              bubble_layout.addWidget(footer_label)

              if emergency:
                  bubble.setStyleSheet("background-color: #ffcccc; border-radius: 10px;")
              else:
                  if src == self.block.my_name:
                      bubble.setStyleSheet("background-color: #cce5ff; border-radius: 10px;")
                  else:
                      bubble.setStyleSheet("background-color: #d9f2d9; border-radius: 10px;")

              h_layout = QtWidgets.QHBoxLayout()
              if src == self.block.my_name:
                  h_layout.addStretch()
                  h_layout.addWidget(bubble)
              else:
                  h_layout.addWidget(bubble)
                  h_layout.addStretch()

              self.chat_layout.insertLayout(self.chat_layout.count()-1, h_layout)
              QtCore.QTimer.singleShot(0, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()))
    my_name: '"userA"'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from PyQt5 import QtWidgets, QtCore
      from collections import deque
      from datetime import datetime

      ADDRESS_MAP = {"userA": 0x00, "userB": 0x01, "userC": 0x02}
      NAME_MAP = {v: k for k, v in ADDRESS_MAP.items()}


      class gui_io(gr.basic_block):
          """
          GUI I/O block with PyQt5 chat window (bubble style)
          """
          def __init__(self, my_name="userA"):
              gr.basic_block.__init__(self, name="gui_io", in_sig=[], out_sig=[])
              self.my_name = my_name

              # Queue for TX
              self.tx_queue = deque()

              # Message ports
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_rx)
              self.message_port_register_out(pmt.intern("out"))

              # Start GUI
              self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication([])
              self.window = ChatWindow(self, self.tx_queue)
              self.window.show()

              # Timer for TX messages
              self.timer = QtCore.QTimer()
              self.timer.timeout.connect(self.process_tx)
              self.timer.start(50)

          def handle_rx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  data = list(pmt.u8vector_elements(pmt.cdr(msg_pmt)))
                  if len(data) < 3:
                      return
                  emergency = bool(data[0])
                  src_addr = data[1]
                  dst_addr = data[2]
                  msg_bytes = data[3:]
                  msg_str = bytes(msg_bytes).decode('utf-8', errors='ignore')
                  src_name = NAME_MAP.get(src_addr, f"Unknown({src_addr})")
                  dst_name = NAME_MAP.get(dst_addr, f"Unknown({dst_addr})")

                  # Thread-safe emit to GUI
                  self.window.new_message_signal.emit(msg_str, emergency, src_name, dst_name)

          def process_tx(self):
              while self.tx_queue:
                  msg, emergency, src, dst = self.tx_queue.popleft()
                  dst_addr = ADDRESS_MAP.get(dst, 0xFF)
                  data_list = [int(emergency), ADDRESS_MAP[self.my_name], dst_addr] + list(msg.encode('utf-8'))
                  out_pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(data_list), data_list))
                  self.message_port_pub(pmt.intern("out"), out_pdu)

          def stop(self):
              self.window.close()
              return True


      class ChatWindow(QtWidgets.QWidget):
          new_message_signal = QtCore.pyqtSignal(str, bool, str, str)

          def __init__(self, block, tx_queue):
              super().__init__()
              self.block = block
              self.tx_queue = tx_queue

              # Connect signal
              self.new_message_signal.connect(self.add_message_bubble)

              self.setWindowTitle(f"Messages: {self.block.my_name}")
              self.setStyleSheet("background-color: #e6f0f8;")
              self.resize(700, 500)

              # Main layout
              self.layout = QtWidgets.QVBoxLayout(self)
              self.layout.setContentsMargins(15, 15, 15, 15)
              self.layout.setSpacing(10)

              # Scroll area for chat messages
              self.scroll_area = QtWidgets.QScrollArea()
              self.scroll_area.setWidgetResizable(True)
              self.scroll_area.setStyleSheet("""
                  QScrollArea { 
                      border: 1px solid #c0c0c0; 
                      border-radius: 8px; 
                      background-color: #ffffff;
                  }
              """)
              self.chat_container = QtWidgets.QWidget()
              self.chat_container.setStyleSheet("background-color: #ffffff; border-radius: 8px;")
              self.chat_layout = QtWidgets.QVBoxLayout(self.chat_container)
              self.chat_layout.setContentsMargins(10, 10, 10, 10)
              self.chat_layout.setSpacing(8)
              self.chat_layout.addStretch(1)
              self.scroll_area.setWidget(self.chat_container)
              self.layout.addWidget(self.scroll_area)

              # Input area
              input_group = QtWidgets.QFrame()
              input_group.setStyleSheet("""
                  QFrame { 
                      background-color: #f0f4f8; 
                      border-radius: 8px; 
                  }
              """)
              input_layout = QtWidgets.QHBoxLayout(input_group)
              input_layout.setContentsMargins(8, 5, 8, 5)
              input_layout.setSpacing(5)

              self.input_line = QtWidgets.QLineEdit()
              self.input_line.setPlaceholderText("Text Message . ")
              self.input_line.setStyleSheet("padding: 5px; font-size: 12pt;")
              input_layout.addWidget(self.input_line, 3)

              self.dst_line = QtWidgets.QLineEdit()
              self.dst_line.setPlaceholderText("To")
              self.dst_line.setFixedWidth(120)
              self.dst_line.setStyleSheet("padding: 5px; font-size: 12pt;")
              input_layout.addWidget(self.dst_line, 1)

              self.emergency_checkbox = QtWidgets.QCheckBox("Emergency")
              self.emergency_checkbox.setStyleSheet("font-size: 11pt; padding: 3px;")
              input_layout.addWidget(self.emergency_checkbox)

              self.send_button = QtWidgets.QPushButton("Send")
              self.send_button.setStyleSheet("""
                  QPushButton { 
                      background-color: #4a90e2; 
                      color: white; 
                      font-size: 12pt; 
                      padding: 6px 12px; 
                      border-radius: 6px; 
                  }
                  QPushButton:hover { background-color: #357ab7; }
              """)
              input_layout.addWidget(self.send_button)

              self.layout.addWidget(input_group)

              # Signals
              self.send_button.clicked.connect(self.queue_message)
              self.input_line.returnPressed.connect(self.queue_message)

          def queue_message(self):
              msg = self.input_line.text()
              dst_name = self.dst_line.text()
              if msg and dst_name in ADDRESS_MAP:
                  emergency_flag = self.emergency_checkbox.isChecked()
                  # Append to TX queue
                  self.tx_queue.append((msg, emergency_flag, self.block.my_name, dst_name))
                  # Display own message immediately
                  self.new_message_signal.emit(msg, emergency_flag, self.block.my_name, dst_name)
                  self.input_line.clear()
                  self.dst_line.clear()
                  self.emergency_checkbox.setChecked(False)

          def add_message_bubble(self, msg, emergency, src, dst):
              bubble = QtWidgets.QFrame()
              bubble.setMaximumWidth(400)
              bubble_layout = QtWidgets.QVBoxLayout(bubble)
              bubble_layout.setContentsMargins(12, 8, 12, 8)
              bubble_layout.setSpacing(2)

              # Message text
              msg_label = QtWidgets.QLabel(msg)
              msg_label.setWordWrap(True)
              msg_label.setStyleSheet("font-size: 12pt;")
              bubble_layout.addWidget(msg_label)

              # Footer: timestamp + other party
              other_name = dst if src == self.block.my_name else src
              timestamp = datetime.now().strftime("%H:%M:%S")
              footer_label = QtWidgets.QLabel(f"{other_name} | {timestamp}")
              footer_label.setStyleSheet("font-size: 8pt; color: #555555;")
              bubble_layout.addWidget(footer_label)

              # Bubble color
              if emergency:
                  bubble.setStyleSheet("background-color: #ffcccc; border-radius: 10px;")
              else:
                  if src == self.block.my_name:
                      bubble.setStyleSheet("background-color: #cce5ff; border-radius: 10px;")
                  else:
                      bubble.setStyleSheet("background-color: #d9f2d9; border-radius: 10px;")

              # Alignment
              h_layout = QtWidgets.QHBoxLayout()
              if src == self.block.my_name:
                  h_layout.addStretch()
                  h_layout.addWidget(bubble)
              else:
                  h_layout.addWidget(bubble)
                  h_layout.addStretch()

              self.chat_layout.insertLayout(self.chat_layout.count()-1, h_layout)
              QtCore.QTimer.singleShot(0, lambda: self.scroll_area.verticalScrollBar().setValue(
                  self.scroll_area.verticalScrollBar().maximum()))
    my_name: '"userB"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import pad, unpad
      import threading
      from collections import deque

      class aes128_block(gr.basic_block):
          """
          AES-128 Encrypt/Decrypt.

          Input TX:  PDU = pmt.cons(meta, data)
              meta: empty
              data: pmt.u8vector [emergency(1B), src_addr(1B), dst_addr(1B), plaintext message bytes]
          Output TX: PDU with encrypted payload (IV + ciphertext), first 3 bytes unchanged

          Input RX:  PDU with encrypted payload
          Output RX: PDU with decrypted payload, first 3 bytes unchanged
          """

          def __init__(self, key=b'0123456789abcdef'):
              gr.basic_block.__init__(self, name="Encrypt/Decrypt.", in_sig=[], out_sig=[])

              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_tx)
              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_rx)
              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              if len(key) != 16:
                  raise ValueError("AES-128 requires 16-byte key")
              self.key = key

              self.tx_queue = deque()
              self.rx_queue = deque()

              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          def handle_tx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  self.tx_queue.append(msg_pmt)

          def handle_rx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  self.rx_queue.append(msg_pmt)

          def tx_loop(self):
              while self.running:
                  if self.tx_queue:
                      msg_pdu = self.tx_queue.popleft()
                      data_pmt = pmt.cdr(msg_pdu)
                      if pmt.is_u8vector(data_pmt):
                          data_bytes = list(pmt.u8vector_elements(data_pmt))
                          if len(data_bytes) < 3:
                              continue
                          header = data_bytes[:3]
                          payload = data_bytes[3:]

                          cipher = AES.new(self.key, AES.MODE_CBC)
                          ct_bytes = cipher.iv + cipher.encrypt(pad(bytes(payload), AES.block_size))

                          out_bytes = header + list(ct_bytes)
                          out_pmt = pmt.init_u8vector(len(out_bytes), out_bytes)
                          out_pdu = pmt.cons(pmt.make_dict(), out_pmt)
                          self.message_port_pub(pmt.intern("out_tx"), out_pdu)
                  else:
                      threading.Event().wait(0.01)

          def rx_loop(self):
              while self.running:
                  if self.rx_queue:
                      msg_pdu = self.rx_queue.popleft()
                      data_pmt = pmt.cdr(msg_pdu)
                      if pmt.is_u8vector(data_pmt):
                          data_bytes = list(pmt.u8vector_elements(data_pmt))
                          if len(data_bytes) < 3 + 16:  # header + IV
                              continue
                          header = data_bytes[:3]
                          ct_bytes = bytes(data_bytes[3:])
                          iv = ct_bytes[:16]
                          ct = ct_bytes[16:]
                          cipher = AES.new(self.key, AES.MODE_CBC, iv=iv)
                          try:
                              pt_bytes = unpad(cipher.decrypt(ct), AES.block_size)
                              out_bytes = header + list(pt_bytes)
                              out_pmt = pmt.init_u8vector(len(out_bytes), out_bytes)
                              out_pdu = pmt.cons(pmt.make_dict(), out_pmt)
                              self.message_port_pub(pmt.intern("out_rx"), out_pdu)
                          except ValueError:
                              continue
                  else:
                      threading.Event().wait(0.01)

          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
    key: 'b''mysecretkey12345'' '
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import pad, unpad
      import threading
      from collections import deque

      class aes128_block(gr.basic_block):
          """
          AES-128 Encrypt/Decrypt Block (PDU-based, Payload Only)
          -------------------------------------------------------
          Input TX:  PDU = pmt.cons(meta, data)
              meta: empty
              data: pmt.u8vector [emergency(1B), src_addr(1B), dst_addr(1B), plaintext message bytes]
          Output TX: PDU with encrypted payload (IV + ciphertext), first 3 bytes unchanged

          Input RX:  PDU with encrypted payload
          Output RX: PDU with decrypted payload, first 3 bytes unchanged
          """

          def __init__(self, key=b'0123456789abcdef'):
              gr.basic_block.__init__(self, name="AES-128", in_sig=[], out_sig=[])

              # Ports
              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_tx)
              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_rx)
              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              # AES key
              if len(key) != 16:
                  raise ValueError("AES-128 requires 16-byte key")
              self.key = key

              # Queues
              self.tx_queue = deque()
              self.rx_queue = deque()

              # Threads
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          # ---------------- Handlers ----------------
          def handle_tx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  self.tx_queue.append(msg_pmt)

          def handle_rx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  self.rx_queue.append(msg_pmt)

          # ---------------- TX loop ----------------
          def tx_loop(self):
              while self.running:
                  if self.tx_queue:
                      msg_pdu = self.tx_queue.popleft()
                      data_pmt = pmt.cdr(msg_pdu)
                      if pmt.is_u8vector(data_pmt):
                          data_bytes = list(pmt.u8vector_elements(data_pmt))
                          if len(data_bytes) < 3:
                              continue
                          header = data_bytes[:3]  # emergency, src_addr, dst_addr
                          payload = data_bytes[3:]

                          # Encrypt payload only
                          cipher = AES.new(self.key, AES.MODE_CBC)
                          ct_bytes = cipher.iv + cipher.encrypt(pad(bytes(payload), AES.block_size))

                          # Output PDU: header + encrypted payload
                          out_bytes = header + list(ct_bytes)
                          out_pmt = pmt.init_u8vector(len(out_bytes), out_bytes)
                          out_pdu = pmt.cons(pmt.make_dict(), out_pmt)
                          self.message_port_pub(pmt.intern("out_tx"), out_pdu)
                  else:
                      threading.Event().wait(0.01)

          # ---------------- RX loop ----------------
          def rx_loop(self):
              while self.running:
                  if self.rx_queue:
                      msg_pdu = self.rx_queue.popleft()
                      data_pmt = pmt.cdr(msg_pdu)
                      if pmt.is_u8vector(data_pmt):
                          data_bytes = list(pmt.u8vector_elements(data_pmt))
                          if len(data_bytes) < 3 + 16:  # header + IV
                              continue
                          header = data_bytes[:3]
                          ct_bytes = bytes(data_bytes[3:])
                          iv = ct_bytes[:16]
                          ct = ct_bytes[16:]
                          cipher = AES.new(self.key, AES.MODE_CBC, iv=iv)
                          try:
                              pt_bytes = unpad(cipher.decrypt(ct), AES.block_size)
                              out_bytes = header + list(pt_bytes)
                              out_pmt = pmt.init_u8vector(len(out_bytes), out_bytes)
                              out_pdu = pmt.cons(pmt.make_dict(), out_pmt)
                              self.message_port_pub(pmt.intern("out_rx"), out_pdu)
                          except ValueError:
                              continue
                  else:
                      threading.Event().wait(0.01)

          # ---------------- Stop ----------------
          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
    key: 'b''mysecretkey12345'' '
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import threading
      from collections import deque
      import time

      class msgQueue(gr.basic_block):
          """
          Message Queue Block with Priority Handling.
          PDU format:
              meta: empty
              data (pmt.u8vector):
                  [emergency(1B), src_addr(1B), dst_addr(1B), message payload bytes]
          """

          def __init__(self):
              gr.basic_block.__init__(self, name="MsgQueue", in_sig=[], out_sig=[])

              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_in_tx)
              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_in_rx)

              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              self.tx_emergency = deque()
              self.tx_normal = deque()
              self.rx_emergency = deque()
              self.rx_normal = deque()

              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          def handle_in_tx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  data_pmt = pmt.cdr(msg_pmt)
                  if pmt.is_u8vector(data_pmt) and len(pmt.u8vector_elements(data_pmt)) >= 3:
                      emergency_flag = bool(pmt.u8vector_elements(data_pmt)[0])
                      if emergency_flag:
                          self.tx_emergency.append(msg_pmt)
                      else:
                          self.tx_normal.append(msg_pmt)

          def handle_in_rx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  data_pmt = pmt.cdr(msg_pmt)
                  if pmt.is_u8vector(data_pmt) and len(pmt.u8vector_elements(data_pmt)) >= 3:
                      emergency_flag = bool(pmt.u8vector_elements(data_pmt)[0])
                      if emergency_flag:
                          self.rx_emergency.append(msg_pmt)
                      else:
                          self.rx_normal.append(msg_pmt)

          def tx_loop(self):
              while self.running:
                  msg = None
                  if self.tx_emergency:
                      msg = self.tx_emergency.popleft()
                  elif self.tx_normal:
                      msg = self.tx_normal.popleft()

                  if msg is not None:
                      out_pdu = pmt.cons(pmt.make_dict(), pmt.cdr(msg))
                      self.message_port_pub(pmt.intern("out_tx"), out_pdu)
                  else:
                      time.sleep(0.01)

          def rx_loop(self):
              while self.running:
                  msg = None
                  if self.rx_emergency:
                      msg = self.rx_emergency.popleft()
                  elif self.rx_normal:
                      msg = self.rx_normal.popleft()

                  if msg is not None:
                      out_pdu = pmt.cons(pmt.make_dict(), pmt.cdr(msg))
                      self.message_port_pub(pmt.intern("out_rx"), out_pdu)
                  else:
                      time.sleep(0.01)

          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
  states: {state: disabled}
- name: epy_block_22_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from PyQt5 import QtWidgets, QtCore
      import sys

      class pdu_probe_qt(gr.basic_block):
          """
          PDU unit8 Probe.
          """
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="PDU-u8 Probe",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_rx)
              self.pdu_queue = []

              self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication(sys.argv)
              self.window = QtWidgets.QWidget()
              self.window.setWindowTitle("PDU Probe")
              self.window.resize(800, 600)
              self.layout = QtWidgets.QVBoxLayout(self.window)
              self.display = QtWidgets.QTextEdit()
              self.display.setReadOnly(True)
              self.layout.addWidget(self.display)
              self.window.show()
              self.timer = QtCore.QTimer()
              self.timer.timeout.connect(self.update_display)
              self.timer.start(50)

          def handle_rx(self, pdu_msg):
              if pmt.is_pair(pdu_msg):
                  self.pdu_queue.append(pdu_msg)

          def update_display(self):
              while self.pdu_queue:
                  pdu_msg = self.pdu_queue.pop(0)
                  meta = pmt.car(pdu_msg)
                  data = pmt.cdr(pdu_msg)

                  if meta == pmt.PMT_NIL:
                      meta_str = "None"
                  else:
                      meta_str = str(meta)

                  if data == pmt.PMT_NIL:
                      data_str = "None"
                  elif pmt.is_u8vector(data):
                      data_str = str(list(pmt.u8vector_elements(data)))
                  elif pmt.is_c32vector(data):
                      data_str = str(list(pmt.c32vector_elements(data)))
                  else:
                      data_str = str(data)

                  self.display.append(f"Meta: {meta_str}\nData: {data_str}\n{'-'*60}")
  states: {state: disabled}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import threading
      from collections import deque
      import time

      class msgQueue(gr.basic_block):
          """
          Message Queue Block with Priority Handling (PDU-based)
          ------------------------------------------------------
          Maintains 4 queues:
              TX: normal, emergency
              RX: normal, emergency
          Always prioritizes emergency messages.

          PDU format:
              meta: empty
              data (pmt.u8vector):
                  [emergency(1B), src_addr(1B), dst_addr(1B), message payload bytes]
          """

          def __init__(self):
              gr.basic_block.__init__(self, name="MsgQueue", in_sig=[], out_sig=[])

              # Message ports
              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_in_tx)
              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_in_rx)

              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              # Queues
              self.tx_emergency = deque()
              self.tx_normal = deque()
              self.rx_emergency = deque()
              self.rx_normal = deque()

              # Thread control
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          # ---------------- Handlers ----------------
          def handle_in_tx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  data_pmt = pmt.cdr(msg_pmt)
                  if pmt.is_u8vector(data_pmt) and len(pmt.u8vector_elements(data_pmt)) >= 3:
                      # Determine emergency from first byte of data
                      emergency_flag = bool(pmt.u8vector_elements(data_pmt)[0])
                      if emergency_flag:
                          self.tx_emergency.append(msg_pmt)
                      else:
                          self.tx_normal.append(msg_pmt)

          def handle_in_rx(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  data_pmt = pmt.cdr(msg_pmt)
                  if pmt.is_u8vector(data_pmt) and len(pmt.u8vector_elements(data_pmt)) >= 3:
                      emergency_flag = bool(pmt.u8vector_elements(data_pmt)[0])
                      if emergency_flag:
                          self.rx_emergency.append(msg_pmt)
                      else:
                          self.rx_normal.append(msg_pmt)

          # ---------------- TX Loop ----------------
          def tx_loop(self):
              while self.running:
                  msg = None
                  if self.tx_emergency:
                      msg = self.tx_emergency.popleft()
                  elif self.tx_normal:
                      msg = self.tx_normal.popleft()

                  if msg is not None:
                      # Pass PDU unchanged (meta empty, data includes headers in first 3 bytes)
                      out_pdu = pmt.cons(pmt.make_dict(), pmt.cdr(msg))
                      self.message_port_pub(pmt.intern("out_tx"), out_pdu)
                  else:
                      time.sleep(0.01)

          # ---------------- RX Loop ----------------
          def rx_loop(self):
              while self.running:
                  msg = None
                  if self.rx_emergency:
                      msg = self.rx_emergency.popleft()
                  elif self.rx_normal:
                      msg = self.rx_normal.popleft()

                  if msg is not None:
                      out_pdu = pmt.cons(pmt.make_dict(), pmt.cdr(msg))
                      self.message_port_pub(pmt.intern("out_rx"), out_pdu)
                  else:
                      time.sleep(0.01)

          # ---------------- Stop ----------------
          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
  states: {}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore
      import sys
      import numpy as np

      class simple_uint8_probe(gr.basic_block):
          """
          UInt8 Stream Probe.
          """
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Tsu8 Probe",
                  in_sig=[np.uint8],
                  out_sig=[]
              )

              self.queue = []
              self.total_bytes = 0
              self.total_bits = 0


              self.app = QtWidgets.QApplication.instance() or QtWidgets.QApplication(sys.argv)
              self.window = QtWidgets.QWidget()
              self.window.setWindowTitle("UInt8 Probe")
              self.window.resize(400, 400)
              layout = QtWidgets.QVBoxLayout(self.window)
              self.display = QtWidgets.QTextEdit()
              self.display.setReadOnly(True)
              layout.addWidget(self.display)
              self.window.show()
              self.timer = QtCore.QTimer()
              self.timer.timeout.connect(self.update_display)
              self.timer.start(50)

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              for val in in0:
                  self.queue.append(val)
                  self.total_bytes += 1
                  self.total_bits += 8
              self.consume(0, len(in0))
              return 0

          def update_display(self):
              while self.queue:
                  val = self.queue.pop(0)
                  self.display.append(f"Value: {val} | Total Bytes: {self.total_bytes} | Total Bits: {self.total_bits}")
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import threading
      from collections import deque
      import time

      class ARQ(gr.basic_block):
          """
          ARQ Transport Layer.
          Stop-and-Wait ARQ with msg_id, ACKs, and emergency prioritization.

          Upper layer PDU:
              meta: empty
              data: [emergency(1B), src_addr(1B), dst_addr(1B), payload bytes]

          Lower layer PDU:
              meta: empty
              data: [msg_id(1B), ack(1B), emergency(1B), src_addr(1B), dst_addr(1B), payload bytes (fixed 1024B)]
          """
          def __init__(self, retransmit_delay=0.2, max_retries=5):
              gr.basic_block.__init__(self, name="Framing & ARQ", in_sig=[], out_sig=[])

              self.payload_len = 1024
              self.retransmit_delay = retransmit_delay
              self.max_retries = max_retries

              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_in_tx)
              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_in_rx)
              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              self.tx_emergency = deque()
              self.tx_normal = deque()
              self.rx_queue = deque()

              self.pending_ack = {} 
              self.next_msg_id = 0

              self.last_delivered = {}

              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          def handle_in_tx(self, pdu):
              if pmt.is_pair(pdu):
                  data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                  emergency = bool(data[0])
                  if emergency:
                      self.tx_emergency.append(pdu)
                  else:
                      self.tx_normal.append(pdu)

          def handle_in_rx(self, pdu):
              if pmt.is_pair(pdu):
                  self.rx_queue.append(pdu)

          def tx_loop(self):
              while self.running:
                  pdu = None
                  if self.tx_emergency:
                      pdu = self.tx_emergency.popleft()
                  elif self.tx_normal:
                      pdu = self.tx_normal.popleft()

                  if pdu:
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                      emergency, src, dst = data[:3]
                      payload = data[3:]

                      if len(payload) < self.payload_len:
                          payload += [0]*(self.payload_len - len(payload))
                      elif len(payload) > self.payload_len:
                          payload = payload[:self.payload_len]

                      msg_id = self.next_msg_id
                      self.next_msg_id = (self.next_msg_id + 1) % 256

                      lower_data = [msg_id, 0, emergency, src, dst] + payload
                      lower_pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(lower_data), lower_data))

                      self.pending_ack[msg_id] = (lower_pdu, time.time(), 1)
                      self.message_port_pub(pmt.intern("out_tx"), lower_pdu)

                  now = time.time()
                  to_remove = []
                  for mid, (frame, ts, retries) in self.pending_ack.items():
                      if now - ts > self.retransmit_delay:
                          if retries >= self.max_retries:
                              to_remove.append(mid)
                          else:
                              self.pending_ack[mid] = (frame, now, retries+1)
                              self.message_port_pub(pmt.intern("out_tx"), frame)
                  for mid in to_remove:
                      del self.pending_ack[mid]

                  time.sleep(0.01)

          def rx_loop(self):
              while self.running:
                  if self.rx_queue:
                      pdu = self.rx_queue.popleft()
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                      if len(data) < 5:
                          continue
                      msg_id, ack_flag, emergency, src, dst = data[:5]
                      payload = data[5:]

                      if ack_flag:
                          if msg_id in self.pending_ack:
                              del self.pending_ack[msg_id]
                          continue

                      ack_data = [msg_id, 1, emergency, src, dst] + [0]*self.payload_len
                      ack_pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(ack_data), ack_data))
                      self.message_port_pub(pmt.intern("out_tx"), ack_pdu)

                      key = (src, dst)
                      if self.last_delivered.get(key) != msg_id:
                          self.last_delivered[key] = msg_id
                          payload_stripped = [b for b in payload if b != 0]
                          upper_data = [emergency, src, dst] + payload_stripped
                          upper_pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(upper_data), upper_data))
                          self.message_port_pub(pmt.intern("out_rx"), upper_pdu)
                  else:
                      time.sleep(0.01)

          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
    max_retries: '50'
    retransmit_delay: '0.2'
  states: {state: disabled}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      import threading
      from collections import deque
      import time

      class ARQ(gr.basic_block):
          """
          ARQ Transport Layer (PDU-based, fixed-length frames)
          ----------------------------------------------------
          Stop-and-Wait ARQ with msg_id, ACKs, and emergency prioritization.

          Upper layer PDU:
              meta: empty
              data: [emergency(1B), src_addr(1B), dst_addr(1B), payload bytes]

          Lower layer PDU:
              meta: empty
              data: [msg_id(1B), ack(1B), emergency(1B), src_addr(1B), dst_addr(1B), payload bytes (fixed 1024B)]
          """
          def __init__(self, retransmit_delay=0.2, max_retries=5):
              gr.basic_block.__init__(self, name="ARQ", in_sig=[], out_sig=[])

              self.payload_len = 1024
              self.retransmit_delay = retransmit_delay
              self.max_retries = max_retries

              # Ports
              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_in_tx)
              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_in_rx)
              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              # Queues
              self.tx_emergency = deque()
              self.tx_normal = deque()
              self.rx_queue = deque()

              # Pending ACKs
              self.pending_ack = {}  # msg_id -> (frame_pdu, timestamp, retries)
              self.next_msg_id = 0

              # Duplicate filter
              self.last_delivered = {}  # (src, dst) -> msg_id

              # Threads
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          # ---------------- Handlers ----------------
          def handle_in_tx(self, pdu):
              if pmt.is_pair(pdu):
                  data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                  emergency = bool(data[0])
                  if emergency:
                      self.tx_emergency.append(pdu)
                  else:
                      self.tx_normal.append(pdu)

          def handle_in_rx(self, pdu):
              if pmt.is_pair(pdu):
                  self.rx_queue.append(pdu)

          # ---------------- TX Loop ----------------
          def tx_loop(self):
              while self.running:
                  pdu = None
                  if self.tx_emergency:
                      pdu = self.tx_emergency.popleft()
                  elif self.tx_normal:
                      pdu = self.tx_normal.popleft()

                  if pdu:
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                      emergency, src, dst = data[:3]
                      payload = data[3:]

                      # Pad payload to 1024B
                      if len(payload) < self.payload_len:
                          payload += [0]*(self.payload_len - len(payload))
                      elif len(payload) > self.payload_len:
                          payload = payload[:self.payload_len]

                      msg_id = self.next_msg_id
                      self.next_msg_id = (self.next_msg_id + 1) % 256

                      lower_data = [msg_id, 0, emergency, src, dst] + payload
                      lower_pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(lower_data), lower_data))

                      self.pending_ack[msg_id] = (lower_pdu, time.time(), 1)
                      self.message_port_pub(pmt.intern("out_tx"), lower_pdu)

                  # Retransmit pending frames
                  now = time.time()
                  to_remove = []
                  for mid, (frame, ts, retries) in self.pending_ack.items():
                      if now - ts > self.retransmit_delay:
                          if retries >= self.max_retries:
                              to_remove.append(mid)
                          else:
                              self.pending_ack[mid] = (frame, now, retries+1)
                              self.message_port_pub(pmt.intern("out_tx"), frame)
                  for mid in to_remove:
                      del self.pending_ack[mid]

                  time.sleep(0.01)

          # ---------------- RX Loop ----------------
          def rx_loop(self):
              while self.running:
                  if self.rx_queue:
                      pdu = self.rx_queue.popleft()
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                      if len(data) < 5:
                          continue
                      msg_id, ack_flag, emergency, src, dst = data[:5]
                      payload = data[5:]

                      if ack_flag:
                          if msg_id in self.pending_ack:
                              del self.pending_ack[msg_id]
                          continue

                      # Send ACK
                      ack_data = [msg_id, 1, emergency, src, dst] + [0]*self.payload_len
                      ack_pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(ack_data), ack_data))
                      self.message_port_pub(pmt.intern("out_tx"), ack_pdu)

                      # Deliver only if not duplicate
                      key = (src, dst)
                      if self.last_delivered.get(key) != msg_id:
                          self.last_delivered[key] = msg_id
                          payload_stripped = [b for b in payload if b != 0]
                          upper_data = [emergency, src, dst] + payload_stripped
                          upper_pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(upper_data), upper_data))
                          self.message_port_pub(pmt.intern("out_rx"), upper_pdu)
                  else:
                      time.sleep(0.01)

          # ---------------- Stop ----------------
          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
    max_retries: '50'
    retransmit_delay: '0.2'
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from collections import deque
      import threading
      import time

      class address_filter(gr.basic_block):
          """
          Address Filtering.
          - TX: Pass-through from upper layer to lower layer.
          - RX: Forward frames to upper layer only if dst_addr matches my_addr.
          - Frame format (PDU):
              meta: empty
              data: [msg_id, ack, emergency, src_addr, dst_addr, payload bytes (1024B)]
          """

          def __init__(self, my_addr=0):
              gr.basic_block.__init__(self, name="AddressFilter", in_sig=[], out_sig=[])

              self.my_addr = my_addr

              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_in_tx)

              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_in_rx)

              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              self.tx_queue = deque()
              self.rx_queue = deque()

              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()


          def handle_in_tx(self, pdu):
              if pmt.is_pair(pdu):
                  self.tx_queue.append(pdu)

          def handle_in_rx(self, pdu):
              if pmt.is_pair(pdu):
                  self.rx_queue.append(pdu)

          def tx_loop(self):
              while self.running:
                  if self.tx_queue:
                      pdu = self.tx_queue.popleft()
                      self.message_port_pub(pmt.intern("out_tx"), pdu)
                  else:
                      time.sleep(0.01)

          def rx_loop(self):
              while self.running:
                  if self.rx_queue:
                      pdu = self.rx_queue.popleft()
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                      if len(data) < 5:
                          continue
                      dst_addr = data[4]
                      if dst_addr == self.my_addr:
                          self.message_port_pub(pmt.intern("out_rx"), pdu)
                  else:
                      time.sleep(0.01)

          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
    my_addr: '0x00'
  states: {state: disabled}
- name: epy_block_7_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from collections import deque
      import threading
      import time

      class address_filter_block(gr.basic_block):
          """
          Address Filtering Block (PDU-based)
          -----------------------------------
          - TX: Pass-through from upper layer to lower layer.
          - RX: Forward frames to upper layer only if dst_addr matches my_addr.
          - Frame format (PDU):
              meta: empty
              data: [msg_id, ack, emergency, src_addr, dst_addr, payload bytes (1024B)]
          """

          def __init__(self, my_addr=0):
              gr.basic_block.__init__(self, name="AddressFilter", in_sig=[], out_sig=[])

              self.my_addr = my_addr

              # Message ports
              self.message_port_register_in(pmt.intern("in_tx"))  # upper -> lower
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_in_tx)

              self.message_port_register_in(pmt.intern("in_rx"))  # lower -> upper
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_in_rx)

              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              # Queues
              self.tx_queue = deque()
              self.rx_queue = deque()

              # Threads
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          # ---------------- Handlers ----------------
          def handle_in_tx(self, pdu):
              if pmt.is_pair(pdu):  # Expecting PDU (meta, data)
                  self.tx_queue.append(pdu)

          def handle_in_rx(self, pdu):
              if pmt.is_pair(pdu):  # Expecting PDU (meta, data)
                  self.rx_queue.append(pdu)

          # ---------------- TX loop ----------------
          def tx_loop(self):
              while self.running:
                  if self.tx_queue:
                      pdu = self.tx_queue.popleft()
                      # Pass-through to lower layer
                      self.message_port_pub(pmt.intern("out_tx"), pdu)
                  else:
                      time.sleep(0.01)

          # ---------------- RX loop ----------------
          def rx_loop(self):
              while self.running:
                  if self.rx_queue:
                      pdu = self.rx_queue.popleft()
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                      if len(data) < 5:
                          continue  # invalid frame
                      dst_addr = data[4]  # dst_addr is 5th byte
                      if dst_addr == self.my_addr:
                          # Forward to upper layer (pass PDU as-is)
                          self.message_port_pub(pmt.intern("out_rx"), pdu)
                      # else: silently drop
                  else:
                      time.sleep(0.01)

          # ---------------- Stop ----------------
          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
    my_addr: '0x01'
  states: {}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from collections import deque
      import threading
      import time
      import zlib

      class crc(gr.basic_block):
          """
          CRC Block.
          TX: Prepend CRC32 to data payload and forward PDU.
          RX: Verify CRC32 at start of data; strip CRC and forward if valid.
          """

          def __init__(self):
              gr.basic_block.__init__(self, name="CRC", in_sig=[], out_sig=[])

              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_in_tx)
              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_in_rx)

              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              self.tx_queue = deque()
              self.rx_queue = deque()

              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          def handle_in_tx(self, pdu):
              if pmt.is_pair(pdu):
                  self.tx_queue.append(pdu)

          def handle_in_rx(self, pdu):
              if pmt.is_pair(pdu):
                  self.rx_queue.append(pdu)

          def tx_loop(self):
              while self.running:
                  if self.tx_queue:
                      pdu = self.tx_queue.popleft()
                      meta = pmt.car(pdu)
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))

                      crc_value = zlib.crc32(bytes(data)) & 0xFFFFFFFF
                      crc_bytes = [(crc_value >> 24) & 0xFF,
                                   (crc_value >> 16) & 0xFF,
                                   (crc_value >> 8) & 0xFF,
                                   crc_value & 0xFF]

                      data_with_crc = crc_bytes + data
                      data_pmt = pmt.init_u8vector(len(data_with_crc), data_with_crc)

                      self.message_port_pub(pmt.intern("out_tx"), pmt.cons(pmt.make_dict(), data_pmt))
                  else:
                      time.sleep(0.01)

          def rx_loop(self):
              while self.running:
                  if self.rx_queue:
                      pdu = self.rx_queue.popleft()
                      meta = pmt.car(pdu)
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                      if len(data) < 4:
                          continue

                      recv_crc_bytes = data[:4]
                      payload = data[4:]
                      recv_crc = (recv_crc_bytes[0] << 24) | (recv_crc_bytes[1] << 16) | \
                                 (recv_crc_bytes[2] << 8) | recv_crc_bytes[3]
                      computed_crc = zlib.crc32(bytes(payload)) & 0xFFFFFFFF
                      if recv_crc == computed_crc:
                          payload_pmt = pmt.init_u8vector(len(payload), payload)
                          self.message_port_pub(pmt.intern("out_rx"), pmt.cons(pmt.make_dict(), payload_pmt))
                  else:
                      time.sleep(0.01)

          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
  states: {state: disabled}
- name: epy_block_8_0
  id: epy_block
  parameters:
    _source_code: |-
      from gnuradio import gr
      import pmt
      from collections import deque
      import threading
      import time
      import zlib

      class crc_block(gr.basic_block):
          """
          CRC Block (PDU-based)
          ---------------------
          TX: Prepend CRC32 to data payload and forward PDU.
          RX: Verify CRC32 at start of data; strip CRC and forward if valid.
          """

          def __init__(self):
              gr.basic_block.__init__(self, name="CRC_PDU", in_sig=[], out_sig=[])

              # Ports
              self.message_port_register_in(pmt.intern("in_tx"))
              self.set_msg_handler(pmt.intern("in_tx"), self.handle_in_tx)
              self.message_port_register_in(pmt.intern("in_rx"))
              self.set_msg_handler(pmt.intern("in_rx"), self.handle_in_rx)

              self.message_port_register_out(pmt.intern("out_tx"))
              self.message_port_register_out(pmt.intern("out_rx"))

              # Queues
              self.tx_queue = deque()
              self.rx_queue = deque()

              # Threads
              self.running = True
              self.tx_thread = threading.Thread(target=self.tx_loop, daemon=True)
              self.rx_thread = threading.Thread(target=self.rx_loop, daemon=True)
              self.tx_thread.start()
              self.rx_thread.start()

          # ---------------- Handlers ----------------
          def handle_in_tx(self, pdu):
              if pmt.is_pair(pdu):
                  self.tx_queue.append(pdu)

          def handle_in_rx(self, pdu):
              if pmt.is_pair(pdu):
                  self.rx_queue.append(pdu)

          # ---------------- TX loop ----------------
          def tx_loop(self):
              while self.running:
                  if self.tx_queue:
                      pdu = self.tx_queue.popleft()
                      meta = pmt.car(pdu)  # empty
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))

                      # Compute CRC32 over the entire payload
                      crc_value = zlib.crc32(bytes(data)) & 0xFFFFFFFF
                      crc_bytes = [(crc_value >> 24) & 0xFF,
                                   (crc_value >> 16) & 0xFF,
                                   (crc_value >> 8) & 0xFF,
                                   crc_value & 0xFF]

                      # Prepend CRC to data
                      data_with_crc = crc_bytes + data
                      data_pmt = pmt.init_u8vector(len(data_with_crc), data_with_crc)

                      # Forward PDU (meta empty, data with CRC)
                      self.message_port_pub(pmt.intern("out_tx"), pmt.cons(pmt.make_dict(), data_pmt))
                  else:
                      time.sleep(0.01)

          # ---------------- RX loop ----------------
          def rx_loop(self):
              while self.running:
                  if self.rx_queue:
                      pdu = self.rx_queue.popleft()
                      meta = pmt.car(pdu)  # empty
                      data = list(pmt.u8vector_elements(pmt.cdr(pdu)))
                      if len(data) < 4:
                          continue  # invalid frame

                      # Extract CRC and payload
                      recv_crc_bytes = data[:4]
                      payload = data[4:]
                      recv_crc = (recv_crc_bytes[0] << 24) | (recv_crc_bytes[1] << 16) | \
                                 (recv_crc_bytes[2] << 8) | recv_crc_bytes[3]

                      # Verify CRC
                      computed_crc = zlib.crc32(bytes(payload)) & 0xFFFFFFFF
                      if recv_crc == computed_crc:
                          # CRC OK: forward PDU without CRC
                          payload_pmt = pmt.init_u8vector(len(payload), payload)
                          self.message_port_pub(pmt.intern("out_rx"), pmt.cons(pmt.make_dict(), payload_pmt))
                      # else: silently drop
                  else:
                      time.sleep(0.01)

          # ---------------- Stop ----------------
          def stop(self):
              self.running = False
              self.tx_thread.join()
              self.rx_thread.join()
              return True
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_3
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_1
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    dev_args: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_1
  id: soapy_bladerf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_rx_B
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_rx_A
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: channel_tx_A
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx_B
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx_A
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: channel_tx_B
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel_rx_A
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: channel_rx_B
  states: {state: disabled}

connections:
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_1, '0']
- [digital_constellation_modulator_0_0, '0', virtual_sink_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0_0, pdus]
- [epy_block_0, out, epy_block_1, in_tx]
- [epy_block_0, out, epy_block_2, in_tx]
- [epy_block_0, out, epy_block_22_0, in]
- [epy_block_0_0, out, epy_block_1_0, in_tx]
- [epy_block_1, out_rx, epy_block_0, in]
- [epy_block_1, out_tx, epy_block_2, in_tx]
- [epy_block_1_0, out_rx, epy_block_0_0, in]
- [epy_block_1_0, out_tx, epy_block_2_0, in_tx]
- [epy_block_2, out_rx, epy_block_1, in_rx]
- [epy_block_2, out_tx, epy_block_0, in]
- [epy_block_2, out_tx, epy_block_4, in_tx]
- [epy_block_2_0, out_rx, epy_block_1_0, in_rx]
- [epy_block_2_0, out_tx, epy_block_4_0, in_tx]
- [epy_block_4, out_rx, epy_block_2, in_rx]
- [epy_block_4, out_tx, epy_block_7, in_tx]
- [epy_block_4_0, out_rx, epy_block_2_0, in_rx]
- [epy_block_4_0, out_tx, epy_block_7_0, in_tx]
- [epy_block_7, out_rx, epy_block_4, in_rx]
- [epy_block_7, out_tx, epy_block_8, in_tx]
- [epy_block_7_0, out_rx, epy_block_4_0, in_rx]
- [epy_block_7_0, out_tx, epy_block_8_0, in_tx]
- [epy_block_8, out_rx, epy_block_3_1, '0']
- [epy_block_8, out_rx, epy_block_7, in_rx]
- [epy_block_8, out_tx, digital_protocol_formatter_async_0, in]
- [epy_block_8_0, out_rx, epy_block_7_0, in_rx]
- [epy_block_8_0, out_tx, digital_protocol_formatter_async_0_0, in]
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_8, in_rx]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_8_0, in_rx]
- [soapy_bladerf_source_0, '0', blocks_tag_debug_0, '0']
- [soapy_bladerf_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_const_sink_x_1, '0']
- [soapy_bladerf_source_1, '0', qtgui_const_sink_x_3, '0']
- [soapy_bladerf_source_1, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_2, '0']
- [virtual_source_0_0, '0', soapy_bladerf_sink_1, '0']
- [virtual_source_1, '0', blocks_tag_debug_0, '0']
- [virtual_source_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_1_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
