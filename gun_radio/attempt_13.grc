options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_8
    output_language: python
    title: pkt_8
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: hdr_format_0
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\PC\University\Semester_3\EN2130_Communication Design Project\Project\apple2.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\PC\University\Semester_3\EN2130_Communication Design Project\Project\apple3.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\PC\University\Semester_3\EN2130_Communication Design Project\Project\apple.txt
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: '32'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Epsilon is the time offset
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '4'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class AckNackGenerator(gr.basic_block):
          """
          Simple ACK/NACK Generator.
          - Receives messages on "ok_in" or "fail_in".
          - Outputs "ack" or "nack" symbols on "out".
          Compatible with PDUFileSource's ctrl_in port.
          """

          def __init__(self):
              gr.basic_block.__init__(self, name="ACK/NACK Generator", in_sig=[], out_sig=[])

              # Input ports
              self.message_port_register_in(pmt.intern("ok_in"))
              self.set_msg_handler(pmt.intern("ok_in"), self.handle_ok)

              self.message_port_register_in(pmt.intern("fail_in"))
              self.set_msg_handler(pmt.intern("fail_in"), self.handle_fail)

              # Output port (to file source ctrl_in)
              self.message_port_register_out(pmt.intern("out"))

          def handle_ok(self, msg):
              print(f"[ACK/NACK] Sending ACK")
              self.message_port_pub(pmt.intern("out"), pmt.intern("ack"))

          def handle_fail(self, msg):
              print(f"[ACK/NACK] Sending NACK")
              self.message_port_pub(pmt.intern("out"), pmt.intern("nack"))
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class TaggedStreamToFile(gr.basic_block):
          """
          Writes incoming PDUs (Tagged Stream converted to PDU) into a file,
          including metadata. Appends all incoming PDUs sequentially.
          """

          def __init__(self, filename="C:/Users/arosh/OneDrive/Desktop/output.txt"):
              gr.basic_block.__init__(
                  self,
                  name="TaggedStreamToFile",
                  in_sig=[],
                  out_sig=[]
              )
              self.filename = filename

              # Register message input port
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              # msg is a PDU = (metadata dict, data vector)
              meta = pmt.car(msg)        # metadata dictionary
              data = pmt.cdr(msg)        # u8vector payload

              # Convert data to Python bytes
              data_bytes = bytes(pmt.u8vector_elements(data))

              # Convert metadata to string
              try:
                  meta_str = pmt.write_string(meta)
              except:
                  meta_str = str(meta)

              # Append to file
              with open(self.filename, "ab") as f:
                  f.write(b"==== NEW PACKET ====\n")
                  f.write(f"Metadata: {meta_str}\n".encode())
                  f.write(b"Payload: " + data_bytes + b"\n\n")
    filename: r"C:\Users\PC\University\Semester_3\EN2130_Communication Design Project\Project\apple2.txt"
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class TaggedStreamToFile(gr.basic_block):
          """
          Writes incoming PDUs (Tagged Stream converted to PDU) into a file,
          including metadata. Appends all incoming PDUs sequentially.
          """

          def __init__(self, filename="C:/Users/arosh/OneDrive/Desktop/output.txt"):
              gr.basic_block.__init__(
                  self,
                  name="TaggedStreamToFile",
                  in_sig=[],
                  out_sig=[]
              )
              self.filename = filename

              # Register message input port
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              # msg is a PDU = (metadata dict, data vector)
              meta = pmt.car(msg)        # metadata dictionary
              data = pmt.cdr(msg)        # u8vector payload

              # Convert data to Python bytes
              data_bytes = bytes(pmt.u8vector_elements(data))

              # Convert metadata to string
              try:
                  meta_str = pmt.write_string(meta)
              except:
                  meta_str = str(meta)

              # Append to file
              with open(self.filename, "ab") as f:
                  f.write(b"==== NEW PACKET ====\n")
                  f.write(f"Metadata: {meta_str}\n".encode())
                  f.write(b"Payload: " + data_bytes + b"\n\n")
    filename: r"C:\Users\PC\University\Semester_3\EN2130_Communication Design Project\Project\apple3.txt"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # PDUFileARQ.py
      from gnuradio import gr
      import pmt
      import os

      class PDUFileARQ(gr.basic_block):
          def __init__(self, file_path="", pdu_size=256):
              gr.basic_block.__init__(
                  self,
                  name="PDUFileARQ",
                  in_sig=None,
                  out_sig=None
              )

              self.file_path = file_path
              self.pdu_size = int(pdu_size) if pdu_size else 256

              # Load file and chunk into list[list[int]]
              self.pdus = []
              if self.file_path and os.path.isfile(self.file_path):
                  with open(self.file_path, "rb") as f:
                      data = f.read()
                  self.pdus = [list(data[i:i+self.pdu_size])
                               for i in range(0, len(data), self.pdu_size)]
              else:
                  if self.file_path:
                      print(f"[ERROR] File not found: {self.file_path}")

              self.current_index = 0
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.message_port_register_in(pmt.intern("control_in"))
              self.set_msg_handler(pmt.intern("control_in"), self.handle_control_msg)

              print(f"[INFO] PDUFileARQ initialized. {len(self.pdus)} PDUs loaded.")

          def start(self):
              # Send the first PDU automatically when flowgraph starts
              if self.pdus:
                  self._publish_current_pdu()
              return True

          def _publish_current_pdu(self):
              """Send current PDU as a proper (meta, data) pair."""
              if not (0 <= self.current_index < len(self.pdus)):
                  return
              pdu_list = self.pdus[self.current_index]
              vec = pmt.init_u8vector(len(pdu_list), pdu_list)
              msg = pmt.cons(pmt.PMT_NIL, vec)
              self.message_port_pub(pmt.intern("pdus_out"), msg)
              print(f"[DEBUG] Sent PDU index={self.current_index}, size={len(pdu_list)}")

          def handle_control_msg(self, msg_pmt):
              """Handle ack/nack control messages (PMT symbol or (meta, symbol) pair)."""
              command = None

              # Case 1: message is a symbol
              if pmt.is_symbol(msg_pmt):
                  command = pmt.symbol_to_string(msg_pmt)

              # Case 2: message is a pair (meta, symbol)
              elif pmt.is_pair(msg_pmt):
                  payload = pmt.cdr(msg_pmt)
                  if pmt.is_symbol(payload):
                      command = pmt.symbol_to_string(payload)

              if command is None:
                  print("[WARNING] Unknown control message format. Ignored.")
                  return

              command = command.lower().strip()
              if command == "ack":
                  if self.current_index < len(self.pdus) - 1:
                      self.current_index += 1
                      self._publish_current_pdu()
                  else:
                      print("[INFO] All PDUs acknowledged.")
              elif command == "nack":
                  print("[DEBUG] NACK received – resending current PDU")
                  self._publish_current_pdu()
              else:
                  print(f"[WARNING] Unknown control command '{command}'")
    file_path: r"C:\Users\PC\University\Semester_3\EN2130_Communication Design Project\Project\apple.txt"
    pdu_size: '32'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_1_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: v1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: v2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: v1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: v2
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_1, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0_1, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_crc_append_0, out, blocks_message_debug_0_1, print]
- [digital_crc_append_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc_check_0, fail, epy_block_0, fail_in]
- [digital_crc_check_0, fail, epy_block_0_0_0, in]
- [digital_crc_check_0, fail, pdu_pdu_to_tagged_stream_1_0_0, pdus]
- [digital_crc_check_0, ok, epy_block_0, ok_in]
- [digital_crc_check_0, ok, epy_block_0_0, in]
- [digital_crc_check_0, ok, pdu_pdu_to_tagged_stream_1_0, pdus]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, out, epy_block_1, control_in]
- [epy_block_1, pdus_out, digital_crc_append_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_1_0_0, '0', blocks_file_sink_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]
- [pdu_tagged_stream_to_pdu_1, pdus, digital_crc_append_0, in]
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_1_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
